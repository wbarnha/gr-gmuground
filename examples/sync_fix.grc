options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: adapt
  id: variable
  parameters:
    value: '0'
  states: {state: disabled}
- name: delay
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '0'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: adapt
  id: parameter
  parameters:
    type: eng_float
    value: '0'
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0_0_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_ctrlport_monitor_0
  id: blocks_ctrlport_monitor
  parameters:
    en: 'True'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: complex
  states: {state: disabled}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '220'
    type: complex
  states: {state: disabled}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    comment: |-
      Empirical-based estimation
      for channel synchronization
    delay: int(samp_rate*146e6*111e-6/(145e6))
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0
  id: blocks_delay
  parameters:
    comment: |-
      Adaptive delay
      for channel synchronization
    delay: int(adapt)
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/wbarnhart/presync/145mhzch1
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/wbarnhart/presync/145mhzch2
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    reserve_items: '1'
    type: float
  states: {}
- name: blocks_vector_sink_x_0_0
  id: blocks_vector_sink_x
  parameters:
    reserve_items: '1'
    type: float
  states: {}
- name: blocks_vector_sink_x_0_1
  id: blocks_vector_sink_x
  parameters:
    reserve_items: '1'
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 1e3
    decim: '50'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 1500, 500)
    type: ccc
  states: {state: disabled}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: adapt
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1e3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e2
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1e3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e2
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: 220 Samples for 145 MHz
  states: {}
- name: phase_sync_0
  id: phase_sync
  parameters: {}
  states: {}
- name: phase_sync_0_0
  id: phase_sync
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    entags: 'False'
    grid: 'True'
    label1: Ch1
    label2: Ch2 (Delay)
    label3: Ch2 (Delay and Phase Adjust)
    label4: Ch2 (No Change)
    label5: Ch2 (Phase Adjust)
    label6: Ch2 (Adaptive Delay)
    nconnections: '6'
    size: 1024*10
    srate: samp_rate
    type: float
    update_time: '0.01'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: satnogs_udp_msg_source_0
  id: satnogs_udp_msg_source
  parameters:
    addr: 127.0.0.1
    msg_type: '0'
    mtu: '32'
    port: '16886'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: adaptor
  states: {}

connections:
- [blocks_complex_to_magphase_0, '0', blocks_vector_sink_x_0_0, '0']
- [blocks_complex_to_magphase_0, '1', blocks_sub_xx_0, '0']
- [blocks_complex_to_magphase_0_0, '0', blocks_vector_sink_x_0, '0']
- [blocks_complex_to_magphase_0_0, '1', blocks_sub_xx_0, '1']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_real_0_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_complex_to_real_0_0_0_0, '0', qtgui_time_sink_x_0, '3']
- [blocks_complex_to_real_0_0_0_0_0, '0', qtgui_time_sink_x_0, '4']
- [blocks_complex_to_real_0_0_0_0_0_0, '0', qtgui_time_sink_x_0, '5']
- [blocks_delay_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_delay_0_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_delay_0_0_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_delay_0_0_0, '0', phase_sync_0, '0']
- [blocks_delay_0_0_0_0, '0', blocks_complex_to_real_0_0_0_0_0_0, '0']
- [blocks_file_source_0, '0', low_pass_filter_0, '0']
- [blocks_file_source_0_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_file_source_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_sub_xx_0, '0', blocks_vector_sink_x_0_1, '0']
- [blocks_sub_xx_0, '0', virtual_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_delay_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_magphase_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_real_0, '0']
- [low_pass_filter_0, '0', phase_sync_0, '1']
- [low_pass_filter_0, '0', phase_sync_0_0, '1']
- [low_pass_filter_0_0, '0', blocks_complex_to_magphase_0_0, '0']
- [low_pass_filter_0_0, '0', blocks_complex_to_real_0_0_0_0, '0']
- [low_pass_filter_0_0, '0', blocks_delay_0, '0']
- [low_pass_filter_0_0, '0', blocks_delay_0_0, '0']
- [low_pass_filter_0_0, '0', blocks_delay_0_0_0, '0']
- [low_pass_filter_0_0, '0', blocks_delay_0_0_0_0, '0']
- [low_pass_filter_0_0, '0', phase_sync_0_0, '0']
- [phase_sync_0, '0', blocks_complex_to_real_0_0_0, '0']
- [phase_sync_0_0, '0', blocks_complex_to_real_0_0_0_0_0, '0']
- [satnogs_udp_msg_source_0, msg, gpredict_MsgPairToVar_0, inpair]

metadata:
  file_format: 1
