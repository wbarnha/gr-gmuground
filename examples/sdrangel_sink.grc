options:
  parameters:
    author: William Barnhart
    generate_options: qt_gui
    id: sdrangel_sink
    output_language: python
    title: SDRAngel Sink
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: sat
  id: variable_qtgui_chooser
  parameters:
    label: Demo Satellite
    labels: '["3CAT-2","AO-73","FloripaSat 1","ITASAT 1","JY1SAT (JO-97)","NAYIF-1 (EO-88)","UKUBE-1"]'
    num_opts: '0'
    options: '[0,1,2,3,4,5,6]'
    type: int
    value: '0'
  states: {}
- name: sat_type
  id: variable
  parameters:
    value: '{0:''3CAT-2'',1:''AO-73'',2:''FloripaSat 1'',3:''ITASAT 1'',4:''JY1-Sat'',5:''Nayif-1'',6:''UKube-1''}'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    comment: From SDRAngel
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '7356'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_source_0_0
  id: blocks_udp_source
  parameters:
    comment: From SDRAngel
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '7356'
    psize: '1472'
    type: float
    vlen: '1'
  states: {state: disabled}
- name: fmusbwide_0
  id: fmusbwide
  parameters:
    filter_width: '20000'
    freq: '0'
    offset: 50e3
  states: {state: disabled}
- name: satellites_satellite_decoder_0
  id: satellites_satellite_decoder
  parameters:
    definition: name
    file: /usr/local/lib/python3/dist-packages/satellites/satyaml/1KUNS-PF.yml
    name: sat_type[sat]
    norad: '99999'
    samp_rate: samp_rate
  states: {}
- name: satnogs_cw_decoder_0
  id: satnogs_cw_decoder
  parameters:
    antenna: '""'
    bfo_freq: 1e3
    bw: '0.0'
    decoded_data_file_path: '"/tmp/.satnogs/data/data"'
    dev_args: '""'
    doppler_correction_per_sec: '20'
    enable_iq_dump: '0'
    file_path: '"test.wav"'
    gain: '0.0'
    iq_file_path: '"/tmp/iq.dat"'
    lo_offset: 100e3
    rigctl_port: '4532'
    rx_freq: 100e6
    samp_rate_rx: '0.0'
    soapy_rx_device: '"driver=invalid"'
    udp_IP: '"127.0.0.1"'
    udp_port: '16887'
    waterfall_file_path: '"/tmp/waterfall.dat"'
    wpm: '20'
  states: {}

connections:
- [blocks_complex_to_real_0, '0', satellites_satellite_decoder_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_real_0, '0']
- [blocks_throttle_0, '0', fmusbwide_0, '0']
- [blocks_throttle_0, '0', satnogs_cw_decoder_0, '0']
- [blocks_throttle_0_0, '0', satellites_satellite_decoder_0, '0']
- [blocks_udp_source_0, '0', blocks_throttle_0, '0']
- [blocks_udp_source_0_0, '0', blocks_throttle_0_0, '0']
- [fmusbwide_0, '0', satellites_satellite_decoder_0, '0']
- [satellites_satellite_decoder_0, out, blocks_message_debug_1, print]

metadata:
  file_format: 1
