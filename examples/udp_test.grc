options:
  parameters:
    author: wbarnhart
    generate_options: no_gui
    id: udp_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '48000'
    type: short
  states: {}
- name: blocks_udp_sink_0_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: Localhost
    port: '7355'
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/wbarnhart/satellite-recordings/itasat1.wav
    repeat: 'True'
  states: {}

connections:
- [blocks_float_to_short_0_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_udp_sink_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_short_0_0, '0']

metadata:
  file_format: 1
