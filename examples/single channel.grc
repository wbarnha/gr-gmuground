options:
  parameters:
    author: William Barnhart
    category: Custom
    generate_options: qt_gui
    id: main
    output_language: python
    run_options: run
    title: Main Block for GMU Ground
  states: {}

blocks:
- name: doppler_freq
  id: variable
  parameters:
    value: freq
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: bb_gain
  id: parameter
  parameters:
    label: baseband gain
    type: eng_float
    value: '20'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/wbarnhart/satellite-recordings/ao73.wav
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/wbarnhart/satellite-recordings/suomi_100.wav
    repeat: 'True'
  states: {state: disabled}
- name: filter_width
  id: parameter
  parameters:
    label: FM filter width
    type: eng_float
    value: '20000'
  states: {}
- name: fmusbwide_0
  id: fmusbwide
  parameters:
    filter_width: '20000'
    freq: freq
    offset: 50e3
  states: {}
- name: freq
  id: parameter
  parameters:
    label: frequency
    short_id: f
    type: eng_float
    value: 145.86e6
  states: {}
- name: freq_corr
  id: parameter
  parameters:
    label: frequency correction (ppm)
    type: eng_float
    value: '0'
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: localhost
    gpredict_port: gpredict_port
    verbose: 'True'
  states: {}
- name: gpredict_port
  id: parameter
  parameters:
    label: GPredict port
    type: intx
    value: '4532'
  states: {}
- name: if_gain
  id: parameter
  parameters:
    label: IF gain
    type: eng_float
    value: '20'
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    comment: Replace with your own source!
    oversample: '0'
    rf_freq: freq
    samp_rate: samp_rate
  states: {}
- name: offset
  id: parameter
  parameters:
    label: centre frequency offset
    type: eng_float
    value: 50e3
  states: {}
- name: rf_gain
  id: parameter
  parameters:
    label: RF gain
    type: eng_float
    value: '40'
  states: {}

connections:
- [blocks_file_source_0, '0', fmusbwide_0, '0']
- [blocks_float_to_complex_0, '0', fmusbwide_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [gpredict_doppler_0, state, blocks_message_debug_0, print]
- [limesdr_source_0, '0', fmusbwide_0, '0']

metadata:
  file_format: 1
