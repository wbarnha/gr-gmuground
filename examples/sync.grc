options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: frequency
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frequency
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frequency
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '50'
    type: complex
  states: {state: disabled}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    type: float
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '2'
    comment: |-
      Vertical Polarization
      Replace with your own source!
      LimeSDR USB: 0009070105C62E09
    oversample: '0'
    rf_freq: frequency
    samp_rate: samp_rate
    serial: 0009070105C62E09
  states: {}
- name: limesdr_source_0_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    comment: |-
      Horizontal Polarization
      Replace with your own source!
      LimeSDR Mini: 1D423F7CD55972
    oversample: '0'
    rf_freq: frequency
    samp_rate: samp_rate
    serial: 1D423F7CD55972
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    entags: 'False'
    grid: 'True'
    label1: Input
    label2: Peaks
    label3: Phase Difference
    label4: ''
    nconnections: '2'
    size: '512'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    entags: 'False'
    grid: 'True'
    label1: Input
    label2: Peaks
    label3: Average
    label4: ''
    nconnections: '4'
    size: '512'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_delay_0, '0']
- [blocks_complex_to_magphase_0, '0', blocks_magphase_to_complex_0, '0']
- [blocks_complex_to_magphase_0, '1', blocks_sub_xx_0_0, '0']
- [blocks_complex_to_magphase_0, '1', blocks_sub_xx_0_0_0, '0']
- [blocks_complex_to_magphase_0, '1', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_magphase_0_0, '0', blocks_vector_sink_x_0, '0']
- [blocks_complex_to_magphase_0_0, '1', blocks_sub_xx_0_0, '1']
- [blocks_complex_to_magphase_0_0, '1', qtgui_time_sink_x_0_0, '1']
- [blocks_delay_0, '0', blocks_throttle_0, '0']
- [blocks_magphase_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_sub_xx_0_0, '0', blocks_sub_xx_0_0_0, '1']
- [blocks_sub_xx_0_0, '0', qtgui_time_sink_x_0_0, '2']
- [blocks_sub_xx_0_0_0, '0', blocks_magphase_to_complex_0, '1']
- [blocks_sub_xx_0_0_0, '0', qtgui_time_sink_x_0_0, '3']
- [blocks_throttle_0, '0', blocks_complex_to_magphase_0_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_throttle_0_0, '0', blocks_complex_to_magphase_0, '0']
- [limesdr_source_0, '0', blocks_throttle_0_0, '0']
- [limesdr_source_0, '1', blocks_throttle_0, '0']
- [limesdr_source_0_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
