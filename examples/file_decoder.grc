options:
  parameters:
    generate_options: qt_gui
    id: file_decoder
    output_language: python
    title: File Decoder
  states: {}

blocks:
- name: nfilts
  id: variable
  parameters:
    value: '16'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(samp_per_sym), 0.35, 11*samp_per_sym*nfilts)
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[-1, 1]'
    dims: '1'
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: bfo
  id: parameter
  parameters:
    label: carrier frequency of the BPSK signal
    type: eng_float
    value: 1.5e3
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: |-
      Insert your file here
      DO NOT ENABLE REPEAT,
      THIS WILL FREEZE GNU RADIO
    file: /home/wbarnha/iqtest
    repeat: 'False'
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_costas_loop_cc_0_0_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.04'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '100'
    rolloff: '0.350'
    samps_per_sym: samp_per_sym
    type: cc
    w: '0.010'
  states: {}
- name: digital_lms_dd_equalizer_cc_0_0
  id: digital_lms_dd_equalizer_cc
  parameters:
    cnst: variable_constellation_0
    mu: '0.03'
    num_taps: '2'
    sps: '2'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: '0.1'
    max_dev: '0.05'
    osps: '2'
    sps: samp_per_sym
    taps: rrc_taps
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: bfo
    decim: '5'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 1300, 500)
    type: fcf
  states: {}
- name: note_0
  id: note
  parameters:
    comment: See gr-satellites for more decoders
    note: For FunCube Satellites
  states: {}
- name: rms_agc_0
  id: rms_agc
  parameters:
    alpha: '1e-2'
    reference: '0.5'
  states: {}
- name: satellites_hdlc_deframer_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'False'
    max_length: '10000'
  states: {}
- name: satellites_nrzi_decode_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {}
- name: show_text_1
  id: show_text
  parameters: {}
  states: {}

connections:
- [blocks_complex_to_real_0_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_complex_to_real_1, '0', freq_xlating_fir_filter_xxx_0_0_1, '0']
- [blocks_file_source_0, '0', blocks_complex_to_real_1, '0']
- [digital_binary_slicer_fb_0, '0', satellites_nrzi_decode_0, '0']
- [digital_costas_loop_cc_0_0_0_0, '0', digital_lms_dd_equalizer_cc_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_lms_dd_equalizer_cc_0_0, '0', blocks_complex_to_real_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_1, '0', rms_agc_0, '0']
- [rms_agc_0, '0', digital_fll_band_edge_cc_0, '0']
- [satellites_hdlc_deframer_0, out, show_text_1, disp_pdu]
- [satellites_nrzi_decode_0, '0', satellites_hdlc_deframer_0, '0']

metadata:
  file_format: 1
