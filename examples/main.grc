options:
  parameters:
    author: William Barnhart
    category: Custom
    generate_options: qt_gui
    id: main
    output_language: python
    run_options: run
    title: Main Block for GMU Ground
  states: {}

blocks:
- name: doppler_freq
  id: variable
  parameters:
    value: freq
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: Selective_Combining_0
  id: Selective_Combining
  parameters: {}
  states: {}
- name: bb_gain
  id: parameter
  parameters:
    label: baseband gain
    type: eng_float
    value: '20'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: filter_width
  id: parameter
  parameters:
    label: FM filter width
    type: eng_float
    value: '20000'
  states: {}
- name: fmusbwide_0
  id: fmusbwide
  parameters:
    filter_width: '20000'
    freq: freq
    offset: 50e3
  states: {}
- name: freq
  id: parameter
  parameters:
    label: frequency
    short_id: f
    type: eng_float
    value: 145.86e6
  states: {}
- name: freq_corr
  id: parameter
  parameters:
    label: frequency correction (ppm)
    type: eng_float
    value: '0'
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: localhost
    gpredict_port: gpredict_port
    verbose: 'True'
  states: {}
- name: gpredict_port
  id: parameter
  parameters:
    label: GPredict port
    type: intx
    value: '4532'
  states: {}
- name: if_gain
  id: parameter
  parameters:
    label: IF gain
    type: eng_float
    value: '20'
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    comment: |-
      Vertical Polarization
      Replace with your own source!
      LimeSDR USB: 0009070105C62E09
    oversample: '0'
    rf_freq: freq
    samp_rate: samp_rate
    serial: 0009070105C62E09
  states: {state: disabled}
- name: limesdr_source_0_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    comment: |-
      Horizontal Polarization
      Replace with your own source!
      LimeSDR Mini: 1D423F7CD55972
    oversample: '0'
    rf_freq: freq
    samp_rate: samp_rate
    serial: 1D423F7CD55972
  states: {state: disabled}
- name: limesdr_source_0_1
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '2'
    comment: |-
      Vertical Polarization
      Replace with your own source!
      LimeSDR USB: 0009070105C62E09
    lna_path_ch0: '3'
    lna_path_ch1: '3'
    oversample: '0'
    rf_freq: freq
    samp_rate: samp_rate
    serial: 0009070105C62E09
  states: {}
- name: offset
  id: parameter
  parameters:
    label: centre frequency offset
    type: eng_float
    value: 50e3
  states: {}
- name: phase_sync_0
  id: phase_sync
  parameters:
    comment: Assumes Horizontal lags behind Vertical
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: (1,0,1,1)
    name: '"Horizontal Channel"'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: (2,0,1,1)
    name: '"Input"'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: '"Vertical Channel"'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rf_gain
  id: parameter
  parameters:
    label: RF gain
    type: eng_float
    value: '40'
  states: {}

connections:
- [Selective_Combining_0, '0', fmusbwide_0, '0']
- [Selective_Combining_0, '0', qtgui_sink_x_0_0, '0']
- [gpredict_doppler_0, freq, qtgui_sink_x_0, freq]
- [gpredict_doppler_0, freq, qtgui_sink_x_0_0, freq]
- [gpredict_doppler_0, freq, qtgui_sink_x_0_0_0, freq]
- [gpredict_doppler_0, state, blocks_message_debug_0, print]
- [limesdr_source_0, '0', Selective_Combining_0, '1']
- [limesdr_source_0, '0', phase_sync_0, '1']
- [limesdr_source_0, '0', qtgui_sink_x_0_0_0, '0']
- [limesdr_source_0_0, '0', phase_sync_0, '0']
- [limesdr_source_0_0, '0', qtgui_sink_x_0, '0']
- [limesdr_source_0_1, '0', phase_sync_0, '0']
- [limesdr_source_0_1, '0', qtgui_sink_x_0, '0']
- [limesdr_source_0_1, '1', Selective_Combining_0, '1']
- [limesdr_source_0_1, '1', phase_sync_0, '1']
- [limesdr_source_0_1, '1', qtgui_sink_x_0_0_0, '0']
- [phase_sync_0, '0', Selective_Combining_0, '0']

metadata:
  file_format: 1
