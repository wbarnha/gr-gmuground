options:
  parameters:
    author: Lime Microsystems
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: FM Receiver
  states: {}

blocks:
- name: baseband
  id: variable_qtgui_entry
  parameters:
    label: RX Baseband [MHz]
    type: real
    value: '915'
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: cut_freq
  id: variable_qtgui_range
  parameters:
    label: Cutoff frequency
    orient: Qt.Horizontal
    start: 1e3
    step: 1e3
    stop: samp_rate/2
    value: 25e3
  states: {}
- name: delay
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '20'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain [dB]
    min_len: '70'
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '60'
    value: '30'
  states: {}
- name: offset
  id: variable
  parameters:
    value: int(1e8)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '7'
  states: {}
- name: trans_width
  id: variable_qtgui_range
  parameters:
    label: Transition width
    orient: Qt.Horizontal
    start: 10e3
    step: '500'
    stop: 500e3
    value: 10e3
  states: {}
- name: analog_random_source_x
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: complex
  states: {state: bypassed}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: delay
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/wbarnhart/bittest
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/wbarnhart/bpsktest
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/wbarnhart/ch1
    offset: offset
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/wbarnhart/ch2
    offset: offset
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {}
- name: digital_constellation_decoder_cb_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {}
- name: digital_constellation_modulator_1
  id: digital_constellation_modulator
  parameters:
    constellation: constellation
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '2'
    verbose: 'True'
  states: {state: disabled}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {state: disabled}
- name: fec_ber_bf_0_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {state: disabled}
- name: fec_ber_bf_0_0_1_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: limesdr_sink_0_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    comment: LimeSDR Mini here!
    gain_dB_ch0: gain
    oversample: '0'
    rf_freq: baseband*1e6
    samp_rate: samp_rate
    serial: 1D423F7CD55972
  states: {state: disabled}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 2e6
    analog_bandw_ch1: 2e6
    channel_mode: '2'
    comment: |-
      1: Vertical
      2: Horizontal
    digital_bandw_ch0: 1.8e6
    digital_bandw_ch1: 1.8e6
    gain_dB_ch0: gain
    gain_dB_ch1: gain
    lna_path_ch0: '3'
    lna_path_ch1: '3'
    oversample: '0'
    rf_freq: baseband*1e6
    samp_rate: samp_rate
    serial: 0009070105C62E09
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cut_freq
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: trans_width
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cut_freq
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: trans_width
    win: firdes.WIN_HAMMING
  states: {}
- name: phase_sync_0
  id: phase_sync
  parameters: {}
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: baseband*1e6
    fftsize: '2048'
    name: '"Transmiting data"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Horizontal BER
    label2: Vertical BER
    label3: Sync BER
    min: '0'
    name: ''
    nconnections: '3'
    type: float
    update_time: '0.1'
  states: {state: disabled}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Horizontal BER
    min: '0'
    name: ''
    type: float
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color2: black
    ctrlpanel: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: 30,0,15,2
    label1: Ch1
    label2: Ch2
    nconnections: '2'
    size: '1024'
    srate: 1*samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    update_time: '0.01'
    ymax: '0.01'
    ymin: '-0.01'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    interp: '25'
    taps: ''
    type: ccc
  states: {state: disabled}

connections:
- [analog_random_source_x, '0', blocks_file_sink_0, '0']
- [analog_random_source_x, '0', digital_constellation_modulator_1, '0']
- [analog_random_source_x, '0', fec_ber_bf_0, '0']
- [analog_random_source_x, '0', fec_ber_bf_0_0, '0']
- [analog_random_source_x, '0', fec_ber_bf_0_0_1_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_0, '0', low_pass_filter_0_0, '0']
- [blocks_delay_0_0, '0', low_pass_filter_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_throttle_0, '0', blocks_delay_0_0, '0']
- [blocks_throttle_0_0, '0', blocks_delay_0, '0']
- [digital_constellation_decoder_cb_0, '0', fec_ber_bf_0, '1']
- [digital_constellation_decoder_cb_0_0, '0', fec_ber_bf_0_0, '1']
- [digital_constellation_decoder_cb_0_0, '0', fec_ber_bf_0_0_1_0, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', fec_ber_bf_0_0_1_0, '1']
- [digital_constellation_modulator_1, '0', rational_resampler_xxx_0, '0']
- [fec_ber_bf_0, '0', qtgui_number_sink_0, '0']
- [fec_ber_bf_0_0, '0', qtgui_number_sink_0, '1']
- [fec_ber_bf_0_0_1_0, '0', qtgui_number_sink_0, '2']
- [fec_ber_bf_0_0_1_0, '0', qtgui_number_sink_0_0, '0']
- [limesdr_source_0, '0', low_pass_filter_0, '0']
- [limesdr_source_0, '1', low_pass_filter_0_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_real_0, '0']
- [low_pass_filter_0, '0', digital_constellation_decoder_cb_0, '0']
- [low_pass_filter_0, '0', digital_constellation_decoder_cb_0_0_0, '0']
- [low_pass_filter_0, '0', phase_sync_0, '1']
- [low_pass_filter_0_0, '0', blocks_complex_to_real_0_0, '0']
- [low_pass_filter_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [low_pass_filter_0_0, '0', phase_sync_0, '0']
- [phase_sync_0, '0', blocks_complex_to_real_0_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_file_sink_0_0, '0']
- [rational_resampler_xxx_0, '0', limesdr_sink_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_const_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
