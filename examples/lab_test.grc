options:
  parameters:
    author: Lime Microsystems
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: FM Receiver
  states: {}

blocks:
- name: baseband
  id: variable_qtgui_entry
  parameters:
    label: RX Baseband [MHz]
    type: real
    value: '446.094'
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: cut_freq
  id: variable_qtgui_range
  parameters:
    label: Cutoff frequency
    orient: Qt.Horizontal
    start: 1e3
    step: 1e3
    stop: samp_rate/2
    value: 500e3
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain [dB]
    min_len: '70'
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '70'
    value: '30'
  states: {}
- name: lna_path
  id: variable_qtgui_chooser
  parameters:
    label: LNA Path
    label0: Auto
    label1: H
    label2: L
    label3: W
    num_opts: '4'
    option1: '1'
    option2: '2'
    option3: '3'
    type: int
    value: '255'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: trans_width
  id: variable_qtgui_range
  parameters:
    label: Transition width
    orient: Qt.Horizontal
    start: 10e3
    step: '500'
    stop: 500e3
    value: 100e3
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: analog_random_source_x
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_wfm_rcv_0_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 480e3
  states: {state: disabled}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '5000000'
    type: complex
  states: {state: bypassed}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/stars/ch1
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/stars/ch2
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/stars/ch1
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/stars/ch2
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/stars/bpsktest
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /home/stars/bittest
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.02'
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {}
- name: digital_constellation_decoder_cb_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {}
- name: digital_constellation_modulator_1
  id: digital_constellation_modulator
  parameters:
    constellation: constellation
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '2'
  states: {state: disabled}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    berminerrors: '10000'
    test_mode: 'False'
  states: {}
- name: fec_ber_bf_0_0
  id: fec_ber_bf
  parameters:
    berminerrors: '10000'
    test_mode: 'False'
  states: {}
- name: fec_ber_bf_0_0_1_0
  id: fec_ber_bf
  parameters:
    berminerrors: '10000'
    test_mode: 'False'
  states: {}
- name: limesdr_sink_0_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    comment: LimeSDR Mini here!
    gain_dB_ch0: gain
    oversample: '0'
    rf_freq: baseband*1e6
    samp_rate: samp_rate
    serial: 1D423F7CD55972
  states: {state: disabled}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 2e6
    analog_bandw_ch1: 2e6
    channel_mode: '2'
    comment: |-
      1: Vertical
      2: Horizontal
    digital_bandw_ch0: 1.8e6
    digital_bandw_ch1: 1.8e6
    gain_dB_ch0: gain
    gain_dB_ch1: gain
    lna_path_ch0: '3'
    lna_path_ch1: '3'
    oversample: '32'
    rf_freq: baseband*1e6
    samp_rate: samp_rate
    serial: 0009070105C62E09
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cut_freq
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: trans_width
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cut_freq
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: trans_width
    win: firdes.WIN_HAMMING
  states: {}
- name: phase_sync_0
  id: phase_sync
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: baseband*1e6
    fftsize: '2048'
    name: '"Transmiting data"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    factor1: 1e6
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: BER
    min: '0'
    name: '"Horizontal"'
    type: float
    unit1: x10^-6
    update_time: '0.1'
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    factor1: 1e6
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,1,1,1
    label1: BER
    min: '0'
    name: '"Vertical"'
    type: float
    unit1: x10^-6
    update_time: '0.1'
  states: {}
- name: qtgui_number_sink_0_0_1_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    factor1: 1e6
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: BER
    min: '0'
    name: '"Synchronized"'
    type: float
    unit1: x10^-6
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: 30,0,15,2
    label1: Horizontal
    label2: Peaks
    label3: Phase Difference
    label4: ''
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    style1: '3'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    update_time: '0.01'
    ymax: '0.1'
    ymin: '-0.1'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    interp: '25'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '200'
    interp: '48'
    taps: ''
    type: ccc
  states: {state: disabled}

connections:
- [analog_random_source_x, '0', digital_constellation_modulator_1, '0']
- [analog_random_source_x, '0', fec_ber_bf_0, '0']
- [analog_random_source_x, '0', fec_ber_bf_0_0, '0']
- [analog_random_source_x, '0', fec_ber_bf_0_0_1_0, '0']
- [analog_sig_source_x_0, '0', rational_resampler_xxx_0, '0']
- [analog_wfm_rcv_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_real_0_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_complex_to_real_0_0_0_0, '0', qtgui_time_sink_x_0, '3']
- [blocks_delay_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_file_source_0, '0', blocks_multiply_const_vxx_0_1_0, '0']
- [blocks_file_source_0_0, '0', blocks_delay_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_multiply_const_vxx_0_1_1, '0']
- [blocks_file_source_1, '0', fec_ber_bf_0, '1']
- [blocks_file_source_1, '0', fec_ber_bf_0_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_const_vxx_0_1_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0_1_1, '0', blocks_complex_to_real_0_0_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', fec_ber_bf_0, '0']
- [digital_constellation_decoder_cb_0, '0', fec_ber_bf_0_0_1_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', fec_ber_bf_0_0, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', fec_ber_bf_0_0_1_0, '1']
- [digital_constellation_modulator_1, '0', rational_resampler_xxx_0, '0']
- [fec_ber_bf_0, '0', qtgui_number_sink_0, '0']
- [fec_ber_bf_0_0, '0', qtgui_number_sink_0_0, '0']
- [fec_ber_bf_0_0_1_0, '0', qtgui_number_sink_0_0_1_0, '0']
- [limesdr_source_0, '0', blocks_file_sink_0, '0']
- [limesdr_source_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [limesdr_source_0, '1', blocks_file_sink_0_0, '0']
- [limesdr_source_0, '1', blocks_multiply_const_vxx_0_1_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_real_0, '0']
- [low_pass_filter_0, '0', digital_constellation_decoder_cb_0, '0']
- [low_pass_filter_0, '0', phase_sync_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_0_0, '0', blocks_complex_to_real_0_0, '0']
- [low_pass_filter_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [low_pass_filter_0_0, '0', phase_sync_0, '1']
- [phase_sync_0, '0', blocks_complex_to_real_0_0_0, '0']
- [phase_sync_0, '0', digital_constellation_decoder_cb_0_0_0, '0']
- [rational_resampler_xxx_0, '0', limesdr_sink_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_wfm_rcv_0_0, '0']

metadata:
  file_format: 1
