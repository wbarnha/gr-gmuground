options:
  parameters:
    author: William Barnhart
    category: gmuground
    generate_options: qt_gui
    id: dual_lime
    output_language: python
    run_options: run
    title: Dual Lime RX
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: channel
  id: variable_qtgui_chooser
  parameters:
    comment: |-
      Delayed Channel refers to the
      channel corresponding to an
      antenna with a longer coaxial line
    gui_hint: (4,0,1,1)
    label: Delayed Channel
    label0: Vertical
    label1: Horizontal
    num_opts: '2'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {state: disabled}
- name: com
  id: variable_qtgui_chooser
  parameters:
    comment: |-
      Remember to arrange the GUI
      blocks to track your layout!
    gui_hint: (1,0,1,1)
    label: Combining Technique
    label0: Selective
    label1: Selective (BPSK Only)
    label2: Equal
    label3: Maximal
    num_opts: '4'
    option1: '1'
    option2: '2'
    option3: '3'
    type: int
    value: '0'
    widget: radio_buttons
  states: {state: disabled}
- name: decimation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: doppler_freq
  id: variable
  parameters:
    value: freq
  states: {}
- name: freq
  id: variable
  parameters:
    value: 145.93*1e6
  states: {}
- name: freq_shift
  id: variable
  parameters:
    value: doppler_freq-freq
  states: {}
- name: freqshift
  id: variable
  parameters:
    value: 146930e3-146411e3
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: (2,0,1,2)
    label: Gain [dB]
    min_len: '70'
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '60'
    value: '30'
  states: {}
- name: guiextra_msgdigitalnumbercontrol_0
  id: guiextra_msgdigitalnumbercontrol
  parameters:
    ThousandsSeparator: ','
    gui_hint: (0,0,1,1)
    lbl: Frequency
    maxFreqHz: 400e6
    minFreqHz: 80e6
    outputmsgname: freq
    readOnly: 'False'
    relBackgroundColor: black
    relFontColor: white
    value: 145.8e6
  states: {}
- name: ledstate
  id: variable_qtgui_toggle_switch
  parameters:
    comment: TBD
    gui_hint: (0,1,1,1)
    initPressed: 'False'
    label: Override Gpredict
    position: '3'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {state: disabled}
- name: sat
  id: variable_qtgui_chooser
  parameters:
    gui_hint: (3,0,1,1)
    label: Demo Satellite
    labels: '["Generic 1k2 FSK","3CAT-2","FloripaSat 1","ITASAT 1","AO-73","JY1SAT (JO-97)","NAYIF-1 (EO-88)"]'
    num_opts: '0'
    options: '[0,1,2,3,4,5,6]'
    type: int
    value: '0'
  states: {}
- name: sat_type
  id: variable
  parameters:
    comment: NORAD IDs
    value: (41732,39444,44885,43786,43803,42017)
  states: {state: disabled}
- name: save
  id: variable_qtgui_toggle_button_msg
  parameters:
    gui_hint: (5,1,1,1)
    initPressed: 'False'
    label: Save Data
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: sig_save
  id: variable_qtgui_chooser
  parameters:
    gui_hint: (5,0,1,1)
    label: Channel to Save
    label0: Combined Signal
    label1: Ch. 1
    label2: Ch. 2
    label3: Filtered
    num_opts: '4'
    option1: '0'
    option2: '1'
    option3: '3'
    type: int
    value: '2'
  states: {}
- name: time_delay
  id: variable
  parameters:
    value: 158e-12*(freq-145e6)+111e-6
  states: {}
- name: transition_bw
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: variable_cw_decoder_0
  id: variable_cw_decoder
  parameters:
    channels: '4'
    confidence: '0.90'
    fft_size: '512'
    max_frame_size: '96'
    min_frame_size: '8'
    overlapping: 512-8
    samp_rate: audio_samp_rate/4
    snr: '10'
    wpm: wpm
  states: {}
- name: AptUI_0
  id: AptUI
  parameters:
    gui_hint: Display@1
  states: {}
- name: Combine_select_0
  id: Combine_select
  parameters:
    filter_alpha: '1e-3'
    gui_hint: (1,0,1,1)
    samp_rate: 600e3
    tag_samps: '1000'
  states: {}
- name: Decode_Demo_0
  id: Decode_Demo
  parameters:
    gui_hint: Misc@1
    inv: '1'
    sat: '0'
  states: {}
- name: Delay_sync_0
  id: Delay_sync
  parameters:
    freq: 146e6
    gui_hint: (4,0,1,1)
    samp_rate: 600e3
  states: {}
- name: Display
  id: qtgui_tab_widget
  parameters:
    gui_hint: (0,2,7,4)
    label0: Waterfall
    label1: NOAA
    label2: Detection
    num_tabs: '3'
  states: {}
- name: Misc
  id: qtgui_tab_widget
  parameters:
    gui_hint: (6,0,1,2)
    label0: Translated Baseband
    label1: Telemetry
    num_tabs: '2'
  states: {}
- name: Selective_Combining_0
  id: Selective_Combining
  parameters:
    comment: |-
      For user's benefit, make it easier
      to ID signals
    filter_alpha: '1e-3'
    tag_samps: '1000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1500'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: Must be included for graceful exiting
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: file_saving_0
  id: file_saving
  parameters:
    freq: 146e6
    samp_rate: 600e3
  states: {}
- name: fosphor_qt_sink_c_0_0_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: freq
    freq_span: samp_rate
    gui_hint: Display@0
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_shift
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -samp_rate/(2*decimation), samp_rate/(2*decimation), transition_bw)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_shift
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -samp_rate/(2*decimation), samp_rate/(2*decimation), transition_bw)
    type: ccc
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: doppler_freq
  states: {}
- name: gpredict_MsgPairToVar_0_0_0
  id: gpredict_MsgPairToVar
  parameters:
    target: freq
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: localhost
    gpredict_port: gpredict_port
    verbose: 'True'
  states: {}
- name: gpredict_port
  id: parameter
  parameters:
    label: GPredict port
    type: intx
    value: '4532'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import datetime
  states: {}
- name: limesdr_source_0_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '2'
    gain_dB_ch0: gain
    gain_dB_ch1: gain
    lna_path_ch0: '2'
    oversample: '0'
    rf_freq: freq
    samp_rate: samp_rate
  states: {state: disabled}
- name: limesdr_source_0_0_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    digital_bandw_ch1: samp_rate/10
    gain_dB_ch0: gain
    gain_dB_ch1: gain
    oversample: '0'
    rf_freq: freq
    samp_rate: samp_rate
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '3000'
    decim: int(decimation)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: offset
  id: parameter
  parameters:
    comment: Applied to Freq Xlat Filter
    label: Frequency Offset
    type: eng_float
    value: 50e3
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: audio_samp_rate
    fc: freq
    fftsize: '512'
    gui_hint: Misc@0
    name: Baseband
    rate: '0.1'
    showrf: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/48e3)
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/48e3)
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/192e3)
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 2.4e6
  states: {}
- name: satnogs_frame_decoder_0
  id: satnogs_frame_decoder
  parameters:
    decoder_object: variable_cw_decoder_0
    itype: complex
    vlen: '1'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: signal
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: ch1
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: ch2
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: filter
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: signal
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: ch1
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: ch2
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: signal
  states: {}
- name: virtual_source_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: filter
  states: {}
- name: wpm
  id: parameter
  parameters:
    type: intx
    value: '20'
  states: {}

connections:
- [Combine_select_0, '0', virtual_sink_0, '0']
- [Combine_select_0, '0', virtual_sink_3, '0']
- [Delay_sync_0, '0', Selective_Combining_0, '0']
- [Delay_sync_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [Delay_sync_0, '0', virtual_sink_1, '0']
- [Delay_sync_0, '1', Selective_Combining_0, '1']
- [Delay_sync_0, '1', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [Delay_sync_0, '1', virtual_sink_1_0, '0']
- [Selective_Combining_0, '0', fosphor_qt_sink_c_0_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_complex_to_real_0, '0', Decode_Demo_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0_0, '0']
- [fosphor_qt_sink_c_0_0_0, freq, gpredict_MsgPairToVar_0, inpair]
- [freq_xlating_fir_filter_xxx_0_0, '0', Combine_select_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', Combine_select_0, '1']
- [gpredict_doppler_0, freq, gpredict_MsgPairToVar_0, inpair]
- [gpredict_doppler_0, state, blocks_message_debug_0, print]
- [guiextra_msgdigitalnumbercontrol_0, valueout, gpredict_MsgPairToVar_0_0_0, inpair]
- [limesdr_source_0_0, '0', Delay_sync_0, '0']
- [limesdr_source_0_0, '1', Delay_sync_0, '1']
- [limesdr_source_0_0_0, '0', Delay_sync_0, '0']
- [limesdr_source_0_0_0, '0', Delay_sync_0, '1']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', satnogs_frame_decoder_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_complex_to_real_0, '0']
- [rational_resampler_xxx_0_0_0, '0', AptUI_0, '0']
- [satnogs_frame_decoder_0, out, blocks_message_debug_0_0, print]
- [save, state, file_saving_0, Save]
- [virtual_source_0, '0', blocks_multiply_xx_0, '1']
- [virtual_source_0, '0', low_pass_filter_0_0, '0']
- [virtual_source_0, '0', rational_resampler_xxx_0_0_0, '0']
- [virtual_source_1, '0', file_saving_0, '0']
- [virtual_source_1_0, '0', file_saving_0, '1']
- [virtual_source_1_0_0, '0', file_saving_0, '2']
- [virtual_source_1_0_0_0, '0', file_saving_0, '3']

metadata:
  file_format: 1
