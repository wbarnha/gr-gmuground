options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: amplitude
  id: variable_qtgui_range
  parameters:
    label: Amplitude
    min_len: '10'
    orient: Qt.Horizontal
    start: '0'
    step: '0.5'
    stop: '10'
    value: '1'
  states: {}
- name: delay
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '0'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: '100'
  states: {state: disabled}
- name: frequency
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude
    freq: frequency
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude
    freq: frequency
    offset: '0'
    phase: 3.1415/4
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_magphase_0_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0_0_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0_0_1
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/wbarnhart/presync/145mhzch1
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/wbarnhart/presync/145mhzch2
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    type: float
  states: {}
- name: blocks_vector_sink_x_0_0
  id: blocks_vector_sink_x
  parameters:
    type: float
  states: {}
- name: blocks_vector_sink_x_0_1
  id: blocks_vector_sink_x
  parameters:
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 1e3
    decim: '50'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 1500, 500)
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 1e3
    decim: '50'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 1500, 500)
    type: ccc
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 2e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e2
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 2e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e2
    win: firdes.WIN_HAMMING
  states: {}
- name: phase_sync_0
  id: phase_sync
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    entags: 'False'
    grid: 'True'
    label1: Original Signal
    label2: Delayed Signal
    label3: Corrected Signal
    nconnections: '3'
    size: '512'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    entags: 'False'
    grid: 'True'
    label1: Original Signal
    label2: Delayed Signal
    label3: Corrected Signal
    nconnections: '3'
    size: '512'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '4'
    ymin: '-4'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle_0_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_delay_0, '0']
- [blocks_add_xx_0, '0', blocks_complex_to_magphase_0_0, '0']
- [blocks_add_xx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_add_xx_0, '0', phase_sync_0, '0']
- [blocks_add_xx_0_0, '0', blocks_complex_to_magphase_0_0_0, '0']
- [blocks_add_xx_0_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_add_xx_0_0, '0', phase_sync_0, '1']
- [blocks_complex_to_magphase_0_0, '0', blocks_vector_sink_x_0, '0']
- [blocks_complex_to_magphase_0_0, '1', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_magphase_0_0_0, '0', blocks_vector_sink_x_0_0, '0']
- [blocks_complex_to_magphase_0_0_0, '1', qtgui_time_sink_x_0_0, '1']
- [blocks_complex_to_magphase_0_0_1, '0', blocks_vector_sink_x_0_1, '0']
- [blocks_complex_to_magphase_0_0_1, '1', qtgui_time_sink_x_0_0, '2']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_real_0_1, '0', qtgui_time_sink_x_0, '2']
- [blocks_delay_0, '0', blocks_throttle_0_0_0, '0']
- [blocks_file_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_file_source_0, '0', low_pass_filter_0, '0']
- [blocks_file_source_0_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_file_source_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_throttle_0_0, '0', blocks_add_xx_0, '0']
- [blocks_throttle_0_0_0, '0', blocks_add_xx_0_0, '1']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_throttle_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_delay_0, '0']
- [low_pass_filter_0, '0', blocks_throttle_0_0, '0']
- [low_pass_filter_0_0, '0', blocks_delay_0, '0']
- [phase_sync_0, '0', blocks_complex_to_magphase_0_0_1, '0']
- [phase_sync_0, '0', blocks_complex_to_real_0_1, '0']

metadata:
  file_format: 1
