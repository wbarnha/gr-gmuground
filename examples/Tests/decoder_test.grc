options:
  parameters:
    author: William Barnhart
    description: Check if decoders can be changed in real-time
    generate_options: qt_gui
    id: decoder_test
    output_language: python
    run_options: run
    title: Decoder Testing
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sat
  id: variable_qtgui_chooser
  parameters:
    label: Demo Satellite
    labels: '["3CAT-2","AO-73","FloripaSat 1","ITASAT 1","JY1SAT (JO-97)","NAYIF-1 (EO-88)","UKUBE-1"]'
    num_opts: '0'
    options: '[0,1,2,3,4,5,6]'
    type: int
    value: '0'
  states: {}
- name: sat_type
  id: variable
  parameters:
    value: '{0:''3CAT-2'',1:''AO-73'',2:''FloripaSat 1'',3:''ITASAT 1'',4:''JY1-Sat'',5:''Nayif-1'',6:''UKube-1''}'
  states: {state: disabled}
- name: sat_type
  id: variable
  parameters:
    comment: NORAD IDs
    value: (41732,39444,44885,43786,43803,42017,40074)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '7'
    output_index: sat
    showports: 'False'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/wbarnha/gr-satellites/satellite-recordings/itasat1.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '3000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {state: bypassed}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '3000'
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: satellites_satellite_decoder_0
  id: satellites_satellite_decoder
  parameters:
    definition: norad
    file: /usr/local/lib/python3/dist-packages/satellites/satyaml/ITASAT_1.yml
    name: str(sat_type)
    norad: sat_type[sat]
    samp_rate: samp_rate
  states: {state: disabled}
- name: satellites_satellite_decoder_0_0
  id: satellites_satellite_decoder
  parameters:
    definition: norad
    file: /usr/local/lib/python3/dist-packages/satellites/satyaml/ITASAT_1.yml
    name: str(sat_type)
    norad: sat_type[0]
    samp_rate: samp_rate
  states: {}
- name: satellites_satellite_decoder_0_0_0
  id: satellites_satellite_decoder
  parameters:
    definition: norad
    file: /usr/local/lib/python3/dist-packages/satellites/satyaml/ITASAT_1.yml
    name: str(sat_type)
    norad: sat_type[1]
    samp_rate: samp_rate
  states: {}
- name: satellites_satellite_decoder_0_0_0_0
  id: satellites_satellite_decoder
  parameters:
    definition: norad
    file: /usr/local/lib/python3/dist-packages/satellites/satyaml/ITASAT_1.yml
    name: str(sat_type)
    norad: sat_type[2]
    samp_rate: samp_rate
  states: {}
- name: satellites_satellite_decoder_0_0_0_0_0
  id: satellites_satellite_decoder
  parameters:
    definition: norad
    file: /usr/local/lib/python3/dist-packages/satellites/satyaml/ITASAT_1.yml
    name: str(sat_type)
    norad: sat_type[3]
    samp_rate: samp_rate
  states: {}
- name: satellites_satellite_decoder_0_0_0_0_0_0
  id: satellites_satellite_decoder
  parameters:
    definition: norad
    file: /usr/local/lib/python3/dist-packages/satellites/satyaml/ITASAT_1.yml
    name: str(sat_type)
    norad: sat_type[4]
    samp_rate: samp_rate
  states: {}
- name: satellites_satellite_decoder_0_0_0_0_0_0_0
  id: satellites_satellite_decoder
  parameters:
    definition: norad
    file: /usr/local/lib/python3/dist-packages/satellites/satyaml/ITASAT_1.yml
    name: str(sat_type)
    norad: sat_type[5]
    samp_rate: samp_rate
  states: {}
- name: satellites_satellite_decoder_0_0_0_0_0_0_0_0
  id: satellites_satellite_decoder
  parameters:
    definition: norad
    file: /usr/local/lib/python3/dist-packages/satellites/satyaml/ITASAT_1.yml
    name: str(sat_type)
    norad: sat_type[6]
    samp_rate: samp_rate
  states: {}
- name: show_text_0
  id: show_text
  parameters: {}
  states: {state: disabled}

connections:
- [blocks_float_to_complex_0, '0', low_pass_filter_0_0, '0']
- [blocks_selector_0, '0', satellites_satellite_decoder_0_0, '0']
- [blocks_selector_0, '1', satellites_satellite_decoder_0_0_0, '0']
- [blocks_selector_0, '2', satellites_satellite_decoder_0_0_0_0, '0']
- [blocks_selector_0, '3', satellites_satellite_decoder_0_0_0_0_0, '0']
- [blocks_selector_0, '4', satellites_satellite_decoder_0_0_0_0_0_0, '0']
- [blocks_selector_0, '5', satellites_satellite_decoder_0_0_0_0_0_0_0, '0']
- [blocks_selector_0, '6', satellites_satellite_decoder_0_0_0_0_0_0_0_0, '0']
- [blocks_wavfile_source_0, '0', low_pass_filter_0_0_0, '0']
- [blocks_wavfile_source_0, '0', satellites_satellite_decoder_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0_0_0, '0', audio_sink_0, '0']
- [low_pass_filter_0_0_0, '0', blocks_float_to_complex_0, '0']
- [low_pass_filter_0_0_0, '0', blocks_selector_0, '0']
- [low_pass_filter_0_0_0, '0', qtgui_freq_sink_x_0, '0']
- [satellites_satellite_decoder_0, out, blocks_message_debug_0, print_pdu]
- [satellites_satellite_decoder_0, out, show_text_0, disp_pdu]
- [satellites_satellite_decoder_0_0, out, blocks_message_debug_0_0, print_pdu]
- [satellites_satellite_decoder_0_0_0, out, blocks_message_debug_0_0, print_pdu]
- [satellites_satellite_decoder_0_0_0_0, out, blocks_message_debug_0_0, print_pdu]
- [satellites_satellite_decoder_0_0_0_0_0, out, blocks_message_debug_0_0, print_pdu]
- [satellites_satellite_decoder_0_0_0_0_0_0, out, blocks_message_debug_0_0, print_pdu]
- [satellites_satellite_decoder_0_0_0_0_0_0_0, out, blocks_message_debug_0_0, print_pdu]
- [satellites_satellite_decoder_0_0_0_0_0_0_0_0, out, blocks_message_debug_0_0, print_pdu]

metadata:
  file_format: 1
