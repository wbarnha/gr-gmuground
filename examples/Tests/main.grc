options:
  parameters:
    author: William Barnhart
    category: Custom
    generate_options: qt_gui
    id: main
    output_language: python
    run_options: run
    title: Main Block for GMU Ground
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 146e6
  states: {}
- name: sat_type
  id: variable
  parameters:
    value: '{0:''3CAT-2'',1:''AO-73'',2:''FloripaSat 1'',3:''ITASAT 1'',4:''JY1-Sat'',5:''Nayif-1'',6:''UKube-1''}'
  states: {}
- name: Combine_select_0
  id: Combine_select
  parameters:
    filter_alpha: '1e-3'
    samp_rate: 600e3
    tag_samps: '1000'
  states: {}
- name: Delay_sync_0
  id: Delay_sync
  parameters:
    freq: 146e6
    samp_rate: 600e3
  states: {}
- name: Display
  id: qtgui_tab_widget
  parameters:
    gui_hint: (0,2,7,4)
    label0: Waterfall
    label1: NOAA
    label2: Telemetry
    num_tabs: '3'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/wbarnha/presync/145mhzch1
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/wbarnha/presync/145mhzch2
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_selector_2
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {state: disabled}
- name: file_saving_0
  id: file_saving
  parameters:
    freq: 146e6
    samp_rate: 600e3
  states: {}
- name: filerepeater_AdvFileSink_0
  id: filerepeater_AdvFileSink
  parameters:
    autostartFreqChange: 'False'
    basedir: /home/presync/
    basefile: gr_record
    bits_per_sample: '8'
    honorFreqChange: 'False'
    honorFreqTags: 'False'
    maxSize: '0'
    maxTimeSec: '0'
    radioCenterFreq: freq
    recordOnStart: 'False'
    sampleRate: samp_rate
    type: complex
    unbuffered: 'False'
    vlen: '1'
  states: {state: disabled}
- name: filerepeater_StateToBool_0
  id: filerepeater_StateToBool
  parameters: {}
  states: {state: disabled}
- name: fmusbwide_0
  id: fmusbwide
  parameters:
    decim: '1'
    filter_width: '20000'
    freq: 146e6
    offset: 50e3
    samp_rate: 600e3
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: freq
    freq_span: samp_rate
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: gpredict_MsgPairToVar_0_0_0
  id: gpredict_MsgPairToVar
  parameters:
    target: freq
  states: {}
- name: gpredict_VarToMsg_0
  id: gpredict_VarToMsg
  parameters:
    msgname: ''
    target: save
  states: {state: disabled}
- name: gpredict_port
  id: parameter
  parameters:
    label: GPredict port
    type: intx
    value: '4532'
  states: {}
- name: limesdr_source_0_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '2'
    digital_bandw_ch0: samp_rate/10
    digital_bandw_ch1: samp_rate/10
    gain_dB_ch0: gain
    gain_dB_ch1: gain
    lna_path_ch0: '2'
    oversample: '0'
    rf_freq: freq
    samp_rate: samp_rate
  states: {state: disabled}
- name: offset
  id: parameter
  parameters:
    label: Frequency Offset
    type: eng_float
    value: 50e3
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 600e3
  states: {}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {}
- name: satellites_satellite_decoder_0
  id: satellites_satellite_decoder
  parameters:
    definition: file
    file: /usr/local/lib/python3/dist-packages/satellites/satyaml/ITASAT_1.yml
    name: 1KUNS-PF
    norad: '99999'
    samp_rate: 48e3
  states: {}
- name: satnogs_cw_decoder_0
  id: satnogs_cw_decoder
  parameters:
    antenna: '""'
    bfo_freq: 1e3
    bw: '0.0'
    decoded_data_file_path: '"/tmp/.satnogs/data/data"'
    dev_args: '""'
    doppler_correction_per_sec: '20'
    enable_iq_dump: '0'
    file_path: '"test.wav"'
    gain: '0.0'
    iq_file_path: '"/tmp/iq.dat"'
    lo_offset: 100e3
    rigctl_port: '4532'
    rx_freq: 100e6
    samp_rate_rx: '0.0'
    soapy_rx_device: '"driver=invalid"'
    udp_IP: '"127.0.0.1"'
    udp_port: '16887'
    waterfall_file_path: '"/tmp/waterfall.dat"'
    wpm: '20'
  states: {state: disabled}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: ch1
  states: {state: disabled}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: ch2
  states: {state: disabled}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: signal
  states: {state: disabled}

connections:
- [Combine_select_0, '0', file_saving_0, '2']
- [Combine_select_0, '0', fmusbwide_0, '0']
- [Combine_select_0, '0', fosphor_qt_sink_c_0, '0']
- [Delay_sync_0, '0', Combine_select_0, '0']
- [Delay_sync_0, '1', Combine_select_0, '1']
- [blocks_file_source_0, '0', Delay_sync_0, '0']
- [blocks_file_source_0, '0', file_saving_0, '0']
- [blocks_file_source_0_0, '0', Delay_sync_0, '1']
- [blocks_file_source_0_0, '0', file_saving_0, '1']
- [blocks_selector_2, '0', filerepeater_AdvFileSink_0, '0']
- [filerepeater_StateToBool_0, bool, blocks_selector_2, en]
- [fmusbwide_0, '0', satellites_satellite_decoder_0, '0']
- [fosphor_qt_sink_c_0, freq, gpredict_MsgPairToVar_0_0_0, inpair]
- [gpredict_VarToMsg_0, msgout, filerepeater_AdvFileSink_0, recordstate]
- [gpredict_VarToMsg_0, msgout, filerepeater_StateToBool_0, state]
- [limesdr_source_0_0, '0', Delay_sync_0, '0']
- [limesdr_source_0_0, '1', Delay_sync_0, '1']
- [satellites_print_timestamp_0, out, blocks_message_debug_1, print_pdu]
- [satellites_satellite_decoder_0, out, satellites_print_timestamp_0, in]
- [virtual_source_1, '0', blocks_selector_2, '0']
- [virtual_source_1_0, '0', blocks_selector_2, '1']
- [virtual_source_1_0_0, '0', blocks_selector_2, '2']

metadata:
  file_format: 1
