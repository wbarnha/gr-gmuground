options:
  parameters:
    author: William Barnhart
    category: gmuground
    generate_options: qt_gui
    id: sdrangel_source
    output_language: python
    run_options: run
    title: Dual Lime RX
  states: {}

blocks:
- name: base
  id: variable_qtgui_entry
  parameters:
    label: Frequency (MHz)
    type: real
    value: '97.1'
  states: {state: disabled}
- name: channel
  id: variable_qtgui_chooser
  parameters:
    comment: |-
      Delayed Channel refers to the
      channel corresponding to an
      antenna with a longer coaxial line
    label: Delayed Channel
    label0: Vertical
    label1: Horizontal
    num_opts: '2'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: com
  id: variable_qtgui_chooser
  parameters:
    label: Combining Technique
    label0: Selective
    label1: Selective (BPSK Only)
    label2: Equal
    label3: Maximal
    num_opts: '4'
    option1: '1'
    option2: '2'
    option3: '3'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: cut_freq
  id: variable_qtgui_range
  parameters:
    label: Cutoff frequency
    orient: Qt.Horizontal
    start: 1e3
    step: 1e3
    stop: samp_rate/2
    value: 100e3
  states: {}
- name: freq
  id: variable
  parameters:
    value: base*1e6
  states: {state: disabled}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain [dB]
    min_len: '70'
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '60'
    value: '30'
  states: {}
- name: samp_rate
  id: variable_qtgui_entry
  parameters:
    label: Sample Rate
    type: real
    value: 2e6
  states: {state: disabled}
- name: sat
  id: variable_qtgui_chooser
  parameters:
    label: Demo Satellite
    labels: '["3CAT-2","AO-73","FloripaSat 1","ITASAT 1","JY1SAT (JO-97)","NAYIF-1 (EO-88)","UKUBE-1"]'
    num_opts: '0'
    options: '[0,1,2,3,4,5,6]'
    type: int
    value: '0'
  states: {}
- name: sat_type
  id: variable
  parameters:
    value: '{0:''3CAT-2'',1:''AO-73'',2:''FloripaSat 1'',3:''ITASAT 1'',4:''JY1SAT (JO-97)'',5:''NAYIF-1 (EO-88)'',6:''UKUBE-1''}'
  states: {}
- name: trans_width
  id: variable_qtgui_range
  parameters:
    label: Transition width
    orient: Qt.Horizontal
    start: 10e3
    step: '500'
    stop: 500e3
    value: 100e3
  states: {}
- name: Maximal_Combining_0
  id: Maximal_Combining
  parameters:
    filter_alpha: '1e-3'
    tag_samps: '1000'
  states: {}
- name: Selective_Combining_0
  id: Selective_Combining
  parameters:
    filter_alpha: '1e-3'
    tag_samps: '1000'
  states: {}
- name: Selective_Combining_BPSK_0
  id: Selective_Combining_BPSK
  parameters:
    filter_alpha: '1e-3'
    tag_samps: '1000'
  states: {}
- name: analog_wfm_rcv_0_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 480e3
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    comment: |-
      Empirical-based estimation
      for channel synchronization
    delay: int(samp_rate*146e6*269.1093e-6/freq)
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: Must be included for graceful exiting
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: com
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: channel
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_1_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: channel
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: fmusbwide_0
  id: fmusbwide
  parameters:
    filter_width: '20000'
    freq: '0'
    offset: 50e3
  states: {}
- name: fosphor_glfw_sink_c_0
  id: fosphor_glfw_sink_c
  parameters:
    freq_center: freq
    freq_span: samp_rate
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: freq
  id: parameter
  parameters:
    label: frequency
    short_id: f
    type: eng_float
    value: 145.85e6
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: freq
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: localhost
    gpredict_port: gpredict_port
    verbose: 'True'
  states: {}
- name: gpredict_port
  id: parameter
  parameters:
    label: GPredict port
    type: intx
    value: '4532'
  states: {}
- name: limesdr_source_0_1
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '2'
    comment: |-
      Replace with your own source!
      LimeSDR USB: 0009070105C62E09
    gain_dB_ch0: gain
    gain_dB_ch1: gain
    lna_path_ch0: '2'
    oversample: '0'
    rf_freq: freq
    samp_rate: samp_rate
    serial: 0009070105C62E09
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cut_freq
    decim: int(samp_rate/0.6e6)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: trans_width
    win: firdes.WIN_HAMMING
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 2e6
  states: {}
- name: satellites_satellite_decoder_0
  id: satellites_satellite_decoder
  parameters:
    definition: name
    file: /usr/local/lib/python3/dist-packages/satellites/satyaml/1KUNS-PF.yml
    name: 1KUNS-PF
    norad: '99999'
    samp_rate: samp_rate
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: signal
  states: {}

connections:
- [Maximal_Combining_0, '0', blocks_selector_0, '3']
- [Selective_Combining_0, '0', blocks_selector_0, '0']
- [Selective_Combining_BPSK_0, '0', blocks_selector_0, '1']
- [analog_wfm_rcv_0_0, '0', audio_sink_0_0, '0']
- [blocks_add_xx_0, '0', blocks_selector_0, '2']
- [blocks_delay_0_0_0, '0', Maximal_Combining_0, '1']
- [blocks_delay_0_0_0, '0', Selective_Combining_0, '1']
- [blocks_delay_0_0_0, '0', Selective_Combining_BPSK_0, '1']
- [blocks_delay_0_0_0, '0', blocks_add_xx_0, '1']
- [blocks_selector_0, '0', fosphor_glfw_sink_c_0, '0']
- [blocks_selector_0, '0', virtual_sink_0, '0']
- [blocks_selector_1, '0', blocks_delay_0_0_0, '0']
- [blocks_selector_1_0, '0', Maximal_Combining_0, '0']
- [blocks_selector_1_0, '0', Selective_Combining_0, '0']
- [blocks_selector_1_0, '0', Selective_Combining_BPSK_0, '0']
- [blocks_selector_1_0, '0', blocks_add_xx_0, '0']
- [fmusbwide_0, '0', satellites_satellite_decoder_0, '0']
- [gpredict_doppler_0, freq, gpredict_MsgPairToVar_0, inpair]
- [gpredict_doppler_0, state, blocks_message_debug_0, print]
- [limesdr_source_0_1, '0', blocks_selector_1, '1']
- [limesdr_source_0_1, '0', blocks_selector_1_0, '0']
- [limesdr_source_0_1, '1', blocks_selector_1, '0']
- [limesdr_source_0_1, '1', blocks_selector_1_0, '1']
- [low_pass_filter_0, '0', analog_wfm_rcv_0_0, '0']
- [satellites_satellite_decoder_0, out, blocks_message_debug_1, print]
- [virtual_source_0, '0', fmusbwide_0, '0']
- [virtual_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
