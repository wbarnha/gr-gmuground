options:
  parameters:
    author: William Barnhart
    category: gmuground
    generate_options: qt_gui
    id: dual_lime
    output_language: python
    run_options: run
    title: Dual Lime RX
  states: {}

blocks:
- name: carrier
  id: variable_qtgui_entry
  parameters:
    gui_hint: (0,0,1,1)
    label: RX Freq [MHz]
    type: real
    value: '145'
  states: {}
- name: channel
  id: variable_qtgui_chooser
  parameters:
    comment: |-
      Delayed Channel refers to the
      channel corresponding to an
      antenna with a longer coaxial line
    gui_hint: (4,0,1,1)
    label: Delayed Channel
    label0: Vertical
    label1: Horizontal
    num_opts: '2'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: com
  id: variable_qtgui_chooser
  parameters:
    gui_hint: (1,0,1,1)
    label: Combining Technique
    label0: Selective
    label1: Selective (BPSK Only)
    label2: Equal
    label3: Maximal
    num_opts: '4'
    option1: '1'
    option2: '2'
    option3: '3'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: doppler_freq
  id: variable
  parameters:
    value: freq
  states: {}
- name: freq
  id: variable
  parameters:
    value: carrier*1e6
  states: {}
- name: freq_shift
  id: variable
  parameters:
    value: doppler_freq-freq
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: (2,0,1,2)
    label: Gain [dB]
    min_len: '70'
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '60'
    value: '30'
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    label: Frequency Offset (MHz)
    orient: Qt.Horizontal
    start: '-1'
    step: '1e-2'
    stop: '1'
    value: '0'
  states: {state: disabled}
- name: sat
  id: variable_qtgui_chooser
  parameters:
    gui_hint: (3,0,1,1)
    label: Demo Satellite
    labels: '["3CAT-2","AO-73","FloripaSat 1","ITASAT 1","JY1SAT (JO-97)","NAYIF-1 (EO-88)","UKUBE-1"]'
    num_opts: '0'
    options: '[0,1,2,3,4,5,6]'
    type: int
    value: '0'
  states: {}
- name: sat_type
  id: variable
  parameters:
    value: '{0:''3CAT-2'',1:''AO-73'',2:''FloripaSat 1'',3:''ITASAT 1'',4:''JY1-Sat'',5:''Nayif-1'',6:''UKube-1''}'
  states: {}
- name: save
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: (5,1,1,1)
    label: Save Data
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: sig_save
  id: variable_qtgui_chooser
  parameters:
    gui_hint: (5,0,1,1)
    label: Channel to Save
    label0: Combined Signal
    label1: Ch. 1
    label2: Ch. 2
    num_opts: '3'
    option1: '0'
    option2: '1'
    type: int
    value: '2'
  states: {}
- name: time_delay
  id: variable
  parameters:
    value: 158e-12*(freq-145e6)+111e-6
  states: {}
- name: variable_qtgui_push_button_0
  id: variable_qtgui_push_button
  parameters:
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {state: disabled}
- name: AptUI_0
  id: AptUI
  parameters:
    gui_hint: Display@1
  states: {}
- name: Display
  id: qtgui_tab_widget
  parameters:
    gui_hint: (0,2,7,4)
    label0: Waterfall
    label1: NOAA
    label2: Telemetry
    num_tabs: '3'
  states: {}
- name: Maximal_Combining_0
  id: Maximal_Combining
  parameters:
    filter_alpha: '1e-3'
    tag_samps: '1000'
  states: {}
- name: Selective_Combining_0
  id: Selective_Combining
  parameters:
    filter_alpha: '1e-3'
    tag_samps: '1000'
  states: {}
- name: Selective_Combining_BPSK_0
  id: Selective_Combining_BPSK
  parameters:
    filter_alpha: '1e-3'
    tag_samps: '1000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1500'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    comment: |-
      Empirical-based estimation
      for channel synchronization
    delay: int(samp_rate*146e6*time_delay/freq)*int((samp_rate*146e6*time_delay/freq)>0)
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0
  id: blocks_delay
  parameters:
    delay: abs(int(samp_rate*146e6*time_delay/freq))*int((samp_rate*146e6*time_delay/freq)<0)
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/wbarnhart/presync/145mhzch1
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/wbarnhart/presync/145mhzch2
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: Must be included for graceful exiting
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: com
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: channel
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_1_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: channel
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_2
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: controls
  id: qtgui_tab_widget
  parameters:
    label0: Frequency Controls
    label1: Channel Controls
    label2: File Processing
    num_tabs: '3'
  states: {state: disabled}
- name: filerepeater_AdvFileSink_0
  id: filerepeater_AdvFileSink
  parameters:
    autostartFreqChange: 'False'
    basedir: /home/wbarnhart/
    basefile: gr_record
    bits_per_sample: '8'
    honorFreqChange: 'False'
    honorFreqTags: 'False'
    maxSize: '0'
    maxTimeSec: '0'
    radioCenterFreq: freq
    recordOnStart: 'False'
    sampleRate: samp_rate
    type: complex
    unbuffered: 'False'
    vlen: '1'
  states: {}
- name: filerepeater_StateToBool_0
  id: filerepeater_StateToBool
  parameters: {}
  states: {}
- name: fosphor_qt_sink_c_0_0_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: freq
    freq_span: samp_rate
    gui_hint: Display@0
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: freq
  id: parameter
  parameters:
    hide: part
    label: frequency
    short_id: f
    type: eng_float
    value: carrier*1e6
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq-doppler_freq+offset
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 1500, 500)
    type: ccc
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: doppler_freq
  states: {}
- name: gpredict_MsgPairToVar_0_0_0
  id: gpredict_MsgPairToVar
  parameters:
    target: freq
  states: {}
- name: gpredict_VarToMsg_0
  id: gpredict_VarToMsg
  parameters:
    msgname: ''
    target: save
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: localhost
    gpredict_port: gpredict_port
    verbose: 'True'
  states: {}
- name: gpredict_port
  id: parameter
  parameters:
    label: GPredict port
    type: intx
    value: '4532'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import datetime
  states: {}
- name: limesdr_source_0_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '2'
    digital_bandw_ch0: samp_rate/10
    digital_bandw_ch1: samp_rate/10
    gain_dB_ch0: gain
    gain_dB_ch1: gain
    lna_path_ch0: '2'
    oversample: '0'
    rf_freq: freq+freq_shift
    samp_rate: samp_rate
    serial: 0009061C02CF232D
  states: {state: disabled}
- name: limesdr_source_0_1
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 1.8e6
    analog_bandw_ch1: 1.8e6
    channel_mode: '2'
    comment: |-
      Replace with your own source!
      LimeSDR USB: 0009070105C62E09
    gain_dB_ch0: gain
    gain_dB_ch1: gain
    lna_path_ch0: '2'
    oversample: '0'
    rf_freq: freq+(doppler_freq-freq)
    samp_rate: samp_rate
    serial: 0009070105C62E09
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 50e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: main_disp
  id: qtgui_tab_widget
  parameters:
    label0: Waterfall
    label1: Telemetry
    num_tabs: '2'
  states: {state: disabled}
- name: offset
  id: parameter
  parameters:
    label: Frequency Offset
    type: eng_float
    value: 50e3
  states: {}
- name: parameter_0
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 600e3
  states: {}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {}
- name: satellites_satellite_decoder_0
  id: satellites_satellite_decoder
  parameters:
    definition: file
    file: /usr/local/lib/python3/dist-packages/satellites/satyaml/ITASAT_1.yml
    name: 1KUNS-PF
    norad: '99999'
    samp_rate: 48e3
  states: {}
- name: satnogs_cw_decoder_0
  id: satnogs_cw_decoder
  parameters:
    antenna: '""'
    bfo_freq: 1e3
    bw: '0.0'
    decoded_data_file_path: '"/tmp/.satnogs/data/data"'
    dev_args: '""'
    doppler_correction_per_sec: '20'
    enable_iq_dump: '0'
    file_path: '"test.wav"'
    gain: '0.0'
    iq_file_path: '"/tmp/iq.dat"'
    lo_offset: 100e3
    rigctl_port: '4532'
    rx_freq: 100e6
    samp_rate_rx: '0.0'
    soapy_rx_device: '"driver=invalid"'
    udp_IP: '"127.0.0.1"'
    udp_port: '16887'
    waterfall_file_path: '"/tmp/waterfall.dat"'
    wpm: '20'
  states: {state: disabled}
- name: show_text_0
  id: show_text
  parameters:
    comment: WIP
    gui_hint: Notebook@2
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: signal
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: ch1
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: ch2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: signal
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: ch1
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: ch2
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: signal
  states: {}

connections:
- [Maximal_Combining_0, '0', blocks_selector_0, '3']
- [Selective_Combining_0, '0', blocks_selector_0, '0']
- [Selective_Combining_BPSK_0, '0', blocks_selector_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_selector_0, '2']
- [blocks_complex_to_real_0, '0', satellites_satellite_decoder_0, '0']
- [blocks_delay_0_0_0, '0', Maximal_Combining_0, '1']
- [blocks_delay_0_0_0, '0', Selective_Combining_0, '1']
- [blocks_delay_0_0_0, '0', Selective_Combining_BPSK_0, '1']
- [blocks_delay_0_0_0, '0', blocks_add_xx_0, '1']
- [blocks_delay_0_0_0, '0', virtual_sink_1_0, '0']
- [blocks_delay_0_0_0_0, '0', Maximal_Combining_0, '0']
- [blocks_delay_0_0_0_0, '0', Selective_Combining_0, '0']
- [blocks_delay_0_0_0_0, '0', Selective_Combining_BPSK_0, '0']
- [blocks_delay_0_0_0_0, '0', blocks_add_xx_0, '0']
- [blocks_delay_0_0_0_0, '0', virtual_sink_1, '0']
- [blocks_file_source_0, '0', blocks_selector_1, '1']
- [blocks_file_source_0, '0', blocks_selector_1_0, '0']
- [blocks_file_source_0_0, '0', blocks_selector_1, '0']
- [blocks_file_source_0_0, '0', blocks_selector_1_0, '1']
- [blocks_multiply_xx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_selector_0, '0', AptUI_0, '0']
- [blocks_selector_0, '0', fosphor_qt_sink_c_0_0_0, '0']
- [blocks_selector_0, '0', virtual_sink_0, '0']
- [blocks_selector_1, '0', blocks_delay_0_0_0, '0']
- [blocks_selector_1_0, '0', blocks_delay_0_0_0_0, '0']
- [blocks_selector_2, '0', filerepeater_AdvFileSink_0, '0']
- [filerepeater_StateToBool_0, bool, blocks_selector_2, en]
- [fosphor_qt_sink_c_0_0_0, freq, gpredict_MsgPairToVar_0_0_0, inpair]
- [freq_xlating_fir_filter_xxx_0, '0', blocks_multiply_xx_0, '1']
- [gpredict_VarToMsg_0, msgout, filerepeater_AdvFileSink_0, recordstate]
- [gpredict_VarToMsg_0, msgout, filerepeater_StateToBool_0, state]
- [gpredict_doppler_0, freq, gpredict_MsgPairToVar_0, inpair]
- [gpredict_doppler_0, state, blocks_message_debug_0, print]
- [limesdr_source_0_0, '0', blocks_selector_1, '1']
- [limesdr_source_0_0, '0', blocks_selector_1_0, '0']
- [limesdr_source_0_0, '1', blocks_selector_1, '0']
- [limesdr_source_0_0, '1', blocks_selector_1_0, '1']
- [limesdr_source_0_1, '0', blocks_selector_1, '1']
- [limesdr_source_0_1, '0', blocks_selector_1_0, '0']
- [limesdr_source_0_1, '1', blocks_selector_1, '0']
- [limesdr_source_0_1, '1', blocks_selector_1_0, '1']
- [low_pass_filter_0, '0', blocks_complex_to_real_0, '0']
- [satellites_print_timestamp_0, out, blocks_message_debug_1, print_pdu]
- [satellites_satellite_decoder_0, out, satellites_print_timestamp_0, in]
- [virtual_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [virtual_source_0, '0', low_pass_filter_0, '0']
- [virtual_source_0, '0', satnogs_cw_decoder_0, '0']
- [virtual_source_1, '0', blocks_selector_2, '0']
- [virtual_source_1_0, '0', blocks_selector_2, '1']
- [virtual_source_1_0_0, '0', blocks_selector_2, '2']

metadata:
  file_format: 1
