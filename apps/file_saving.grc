options:
  parameters:
    author: William Barnhart
    category: gmuground
    description: File Control
    generate_options: hb_qt_gui
    id: file_saving
    output_language: python
    title: File Control
  states: {}

blocks:
- name: sig_save
  id: variable_qtgui_chooser
  parameters:
    label: Channel to Save
    label0: Combined Signal
    label1: Ch. 1
    label2: Ch. 2
    num_opts: '3'
    option1: '0'
    option2: '1'
    type: int
    value: '2'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /home/stars/test
    type: complex
  states: {state: disabled}
- name: blocks_selector_2
  id: blocks_selector
  parameters:
    enabled: 'False'
    input_index: sig_save
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: filerepeater_AdvFileSink_0
  id: filerepeater_AdvFileSink
  parameters:
    autostartFreqChange: 'False'
    basedir: /home/stars/
    basefile: gr_record
    bits_per_sample: '8'
    honorFreqChange: 'False'
    honorFreqTags: 'False'
    maxSize: '0'
    maxTimeSec: '0'
    radioCenterFreq: freq
    recordOnStart: 'False'
    sampleRate: samp_rate
    type: complex
    unbuffered: 'False'
    vlen: '1'
  states: {}
- name: filerepeater_StateToBool_0
  id: filerepeater_StateToBool
  parameters: {}
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Frequency
    type: eng_float
    value: 146e6
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: Ch 1
    type: complex
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: Ch 2
    type: complex
  states: {}
- name: pad_source_0_0_0
  id: pad_source
  parameters:
    label: Combined
    type: complex
  states: {}
- name: pad_source_0_0_0_0
  id: pad_source
  parameters:
    label: Filtered
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: Save
    type: message
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 600e3
  states: {}

connections:
- [blocks_selector_2, '0', blocks_file_sink_0, '0']
- [blocks_selector_2, '0', filerepeater_AdvFileSink_0, '0']
- [filerepeater_StateToBool_0, bool, blocks_selector_2, en]
- [pad_source_0, '0', blocks_selector_2, '0']
- [pad_source_0_0, '0', blocks_selector_2, '1']
- [pad_source_0_0_0, '0', blocks_selector_2, '2']
- [pad_source_0_0_0_0, '0', blocks_selector_2, '3']
- [pad_source_1, out, filerepeater_AdvFileSink_0, recordstate]
- [pad_source_1, out, filerepeater_StateToBool_0, state]

metadata:
  file_format: 1
