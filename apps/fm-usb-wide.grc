options:
  parameters:
    author: William Barnhart
    category: gmuground
    generate_options: hb_qt_gui
    id: fmusbwide
    output_language: python
    title: FM/USB/USB_Wide Processor
  states: {}

blocks:
- name: doppler_freq
  id: variable
  parameters:
    value: freq
  states: {}
- name: mod
  id: variable_qtgui_chooser
  parameters:
    label: Modulation
    label0: FM
    label1: USB
    label2: USB (Wide)
    num_opts: '3'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '0.2'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1500'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '12000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_float_to_short_0_0_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: mod
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    showports: 'False'
    type: short
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: mod
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    showports: 'False'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '48000'
    type: short
  states: {}
- name: blocks_udp_sink_0_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: Localhost
    port: '7355'
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: filter_width
  id: parameter
  parameters:
    label: FM filter width
    type: eng_float
    value: '20000'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: frequency
    short_id: f
    type: eng_float
    value: '0'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: doppler_freq-freq+offset
    decim: '50'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, filter_width/2.0, filter_width/20.0)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: doppler_freq-freq+offset
    decim: '50'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 1500, 500)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: doppler_freq-freq+offset
    decim: '50'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 1500, 500)
    type: ccc
  states: {}
- name: note_0
  id: note
  parameters:
    note: FM
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: USB
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: Wide USB
  states: {}
- name: offset
  id: parameter
  parameters:
    label: centre frequency offset
    type: eng_float
    value: 50e3
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_float_to_short_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '0']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_1, '1']
- [blocks_complex_to_real_0, '0', blocks_float_to_short_0_0, '0']
- [blocks_complex_to_real_0_0, '0', blocks_float_to_short_0_0_0, '0']
- [blocks_float_to_short_0, '0', blocks_selector_0, '0']
- [blocks_float_to_short_0_0, '0', blocks_selector_0, '1']
- [blocks_float_to_short_0_0_0, '0', blocks_selector_0, '2']
- [blocks_multiply_xx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_xx_0, '0', blocks_selector_0_0, '1']
- [blocks_multiply_xx_0_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_selector_0_0, '2']
- [blocks_multiply_xx_1, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_multiply_xx_1, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_multiply_xx_1, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [blocks_selector_0, '0', blocks_throttle_0, '0']
- [blocks_selector_0_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle_0, '0', blocks_udp_sink_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_selector_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_multiply_xx_0, '1']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', blocks_multiply_xx_0_0, '1']
- [pad_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [pad_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [pad_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [pad_source_0_0, '0', blocks_multiply_xx_1, '0']

metadata:
  file_format: 1
