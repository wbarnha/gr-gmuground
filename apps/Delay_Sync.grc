options:
  parameters:
    author: William Barnhart
    category: gmuground
    description: Delay Synchronization
    generate_options: hb_qt_gui
    id: Delay_sync
    output_language: python
    title: Delay Synchronization
  states: {}

blocks:
- name: channel
  id: variable_qtgui_chooser
  parameters:
    comment: |-
      Delayed Channel refers to the
      channel corresponding to an
      antenna with a longer coaxial line
    label: Delayed Channel
    label0: Vertical
    label1: Horizontal
    num_opts: '2'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: time_delay
  id: variable
  parameters:
    value: 158e-12*(freq-145e6)+111e-6
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    comment: |-
      Empirical-based estimation
      for channel synchronization
    delay: int(samp_rate*146e6*time_delay/freq)*int((samp_rate*146e6*time_delay/freq)>0)
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0
  id: blocks_delay
  parameters:
    delay: abs(int(samp_rate*146e6*time_delay/freq))*int((samp_rate*146e6*time_delay/freq)<0)
    type: complex
  states: {}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: channel
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_1_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: channel
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    reserve_items: '1'
    type: float
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Frequency
    type: eng_float
    value: 146e6
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: Ch1
    type: complex
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: Ch2
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: Ch1
    type: complex
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: Ch2
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    value: 600e3
  states: {}

connections:
- [blocks_complex_to_magphase_0, '0', blocks_magphase_to_complex_0, '0']
- [blocks_complex_to_magphase_0, '1', blocks_sub_xx_0, '0']
- [blocks_complex_to_magphase_0, '1', blocks_sub_xx_0_0, '0']
- [blocks_complex_to_magphase_0_0, '0', blocks_vector_sink_x_0, '0']
- [blocks_complex_to_magphase_0_0, '1', blocks_sub_xx_0, '1']
- [blocks_delay_0_0_0, '0', blocks_complex_to_magphase_0_0, '0']
- [blocks_delay_0_0_0_0, '0', blocks_complex_to_magphase_0, '0']
- [blocks_delay_0_0_0_0, '0', pad_sink_0, '0']
- [blocks_magphase_to_complex_0, '0', pad_sink_0_0, '0']
- [blocks_selector_1, '0', blocks_delay_0_0_0, '0']
- [blocks_selector_1_0, '0', blocks_delay_0_0_0_0, '0']
- [blocks_sub_xx_0, '0', blocks_sub_xx_0_0, '1']
- [blocks_sub_xx_0_0, '0', blocks_magphase_to_complex_0, '1']
- [pad_source_0, '0', blocks_selector_1, '1']
- [pad_source_0, '0', blocks_selector_1_0, '0']
- [pad_source_0_0, '0', blocks_selector_1, '0']
- [pad_source_0_0, '0', blocks_selector_1_0, '1']

metadata:
  file_format: 1
