options:
  parameters:
    author: William Barnhart
    category: Custom
    generate_options: qt_gui
    id: main
    output_language: python
    run_options: run
    title: Main Block for GMU Ground
  states: {}

blocks:
- name: com
  id: variable_qtgui_chooser
  parameters:
    label: Combining Technique
    label0: Maximal
    label1: Selective
    label2: Equal
    num_opts: '3'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain [dB]
    min_len: '70'
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '60'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: Maximal_Combining_0
  id: Maximal_Combining
  parameters:
    filter_alpha: '1e-3'
    tag_samps: '1000'
  states: {}
- name: Selective_Combining_0
  id: Selective_Combining
  parameters:
    filter_alpha: '1e-3'
    tag_samps: '1000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: int(samp_rate*146e6*269.1093e-6/freq)
    type: complex
  states: {state: bypassed}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    comment: |-
      Bypass this block for the channel that 
      has the delay due to longer coaxial
    delay: int(samp_rate*146e6*269.1093e-6/freq)
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: com
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_tcp_server_sink_0
  id: blocks_tcp_server_sink
  parameters:
    ipaddr: 127.0.0.1
    noblock: 'False'
    port: '9090'
    type: complex
    vlen: '1'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: frequency
    short_id: f
    type: eng_float
    value: 145.85e6
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: freq
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: localhost
    gpredict_port: gpredict_port
    verbose: 'True'
  states: {}
- name: gpredict_port
  id: parameter
  parameters:
    label: GPredict port
    type: intx
    value: '4532'
  states: {}
- name: limesdr_source_0_1
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '2'
    comment: |-
      Replace with your own source!
      LimeSDR USB: 0009070105C62E09
    gain_dB_ch0: gain
    gain_dB_ch1: gain
    lna_path_ch0: '2'
    oversample: '0'
    rf_freq: freq
    samp_rate: samp_rate
    serial: 0009070105C62E09
  states: {}

connections:
- [Maximal_Combining_0, '0', blocks_selector_0, '0']
- [Selective_Combining_0, '0', blocks_selector_0, '1']
- [blocks_add_xx_0, '0', blocks_selector_0, '2']
- [blocks_delay_0_0, '0', Maximal_Combining_0, '0']
- [blocks_delay_0_0, '0', Selective_Combining_0, '0']
- [blocks_delay_0_0, '0', blocks_add_xx_0, '0']
- [blocks_delay_0_0_0, '0', Maximal_Combining_0, '1']
- [blocks_delay_0_0_0, '0', Selective_Combining_0, '1']
- [blocks_delay_0_0_0, '0', blocks_add_xx_0, '1']
- [blocks_selector_0, '0', blocks_tcp_server_sink_0, '0']
- [gpredict_doppler_0, freq, gpredict_MsgPairToVar_0, inpair]
- [gpredict_doppler_0, state, blocks_message_debug_0, print]
- [limesdr_source_0_1, '0', blocks_delay_0_0, '0']
- [limesdr_source_0_1, '1', blocks_delay_0_0_0, '0']

metadata:
  file_format: 1
