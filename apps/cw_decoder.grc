options:
  parameters:
    author: Manolis Surligas (surligas@gmail.com)
    category: Custom
    description: A CW (Morse) Decoder
    generate_options: hb
    id: satnogs_cw_decoder
    output_language: python
    run_options: run
    title: CW Decoder
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: dot_samples
  id: variable
  parameters:
    value: int((1.2 / wpm) / (1.0 / (audio_samp_rate / 10.0)))
  states: {}
- name: variable_cw_decoder_0
  id: variable_cw_decoder
  parameters:
    channels: '4'
    confidence: '0.90'
    fft_size: '512'
    max_frame_size: '96'
    min_frame_size: '8'
    overlapping: 512-8
    samp_rate: audio_samp_rate/4
    snr: '10'
    wpm: wpm
  states: {}
- name: analog_agc2_xx_0_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '0.01'
    decay_rate: '0.001'
    gain: '0.0'
    max_gain: '65536'
    reference: '0.015'
    type: complex
  states: {state: disabled}
- name: antenna
  id: parameter
  parameters:
    type: str
    value: '""'
  states: {}
- name: bfo_freq
  id: parameter
  parameters:
    comment: |-
      The bfo_freq shifts the carrier from 0 Hz to a
      frequency that corresponds to the CW audio
      tone. This tone is typically 1 kHz.
    type: eng_float
    value: 1e3
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2.0 * math.pi * (bfo_freq / audio_samp_rate)
  states: {state: disabled}
- name: bw
  id: parameter
  parameters:
    comment: |-
      The bandwidth should configure RF filters on some devices.
      Set to 0.0 for automatic calculation.
    label: Bandwidth
    type: eng_float
    value: '0.0'
  states: {}
- name: decoded_data_file_path
  id: parameter
  parameters:
    type: str
    value: '"/tmp/.satnogs/data/data"'
  states: {}
- name: dev_args
  id: parameter
  parameters:
    label: Device arguments
    type: str
    value: '""'
  states: {}
- name: doppler_correction_per_sec
  id: parameter
  parameters:
    type: intx
    value: '20'
  states: {}
- name: enable_iq_dump
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: file_path
  id: parameter
  parameters:
    type: str
    value: '"test.wav"'
  states: {}
- name: gain
  id: parameter
  parameters:
    type: eng_float
    value: '0.0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import satnogs
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import math
  states: {}
- name: iq_file_path
  id: parameter
  parameters:
    type: str
    value: '"/tmp/iq.dat"'
  states: {}
- name: lo_offset
  id: parameter
  parameters:
    comment: |-
      To avoid the SDR carrier at the DC
      we shift the LO a little further
    type: eng_float
    value: 100e3
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '3000'
    decim: '1'
    gain: '1'
    samp_rate: audio_samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rigctl_port
  id: parameter
  parameters:
    type: intx
    value: '4532'
  states: {}
- name: rx_freq
  id: parameter
  parameters:
    type: eng_float
    value: 100e6
  states: {}
- name: samp_rate_rx
  id: parameter
  parameters:
    label: Device Sampling rate
    type: eng_float
    value: '0.0'
  states: {}
- name: satnogs_frame_decoder_0
  id: satnogs_frame_decoder
  parameters:
    decoder_object: variable_cw_decoder_0
    itype: complex
    vlen: '1'
  states: {}
- name: satnogs_frame_file_sink_0_0
  id: satnogs_frame_file_sink
  parameters:
    output_type: '0'
    prefix_name: decoded_data_file_path
  states: {state: disabled}
- name: satnogs_json_converter_0
  id: satnogs_json_converter
  parameters:
    extra: ''
  states: {state: disabled}
- name: satnogs_ogg_encoder_0
  id: satnogs_ogg_encoder
  parameters:
    filename: file_path
    quality: '1.0'
    samp_rate: audio_samp_rate
  states: {state: disabled}
- name: satnogs_udp_msg_sink_0_0
  id: satnogs_udp_msg_sink
  parameters:
    addr: udp_IP
    mtu: '1500'
    port: udp_port
  states: {state: disabled}
- name: soapy_rx_device
  id: parameter
  parameters:
    type: str
    value: '"driver=invalid"'
  states: {}
- name: udp_IP
  id: parameter
  parameters:
    type: str
    value: '"127.0.0.1"'
  states: {}
- name: udp_port
  id: parameter
  parameters:
    type: intx
    value: '16887'
  states: {}
- name: waterfall_file_path
  id: parameter
  parameters:
    type: str
    value: '"/tmp/waterfall.dat"'
  states: {}
- name: wpm
  id: parameter
  parameters:
    type: intx
    value: '20'
  states: {}

connections:
- [analog_agc2_xx_0_0, '0', blocks_rotator_cc_0_0, '0']
- [blocks_complex_to_real_0, '0', satnogs_ogg_encoder_0, '0']
- [blocks_rotator_cc_0_0, '0', blocks_complex_to_real_0, '0']
- [low_pass_filter_0_0, '0', analog_agc2_xx_0_0, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_0, '0']
- [pad_source_0, '0', low_pass_filter_0_0, '0']
- [rational_resampler_xxx_0, '0', satnogs_frame_decoder_0, '0']
- [satnogs_frame_decoder_0, out, blocks_message_debug_0, print]
- [satnogs_frame_decoder_0, out, satnogs_json_converter_0, in]
- [satnogs_json_converter_0, out, satnogs_frame_file_sink_0_0, frame]
- [satnogs_json_converter_0, out, satnogs_udp_msg_sink_0_0, in]

metadata:
  file_format: 1
