options:
  parameters:
    author: William Barnhart
    category: gmuground
    description: Uses two receiving channels for opposite polarizations to produce a signal with greater SNR.
    generate_options: hb
    id: phase_sync
    output_language: python
    title: Phase Synchronization
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    reserve_items: '1'
    type: float
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: sig1
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: sig1
    type: complex
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: sig2
    type: complex
  states: {}

connections:
- [blocks_complex_to_magphase_0, '0', blocks_magphase_to_complex_0, '0']
- [blocks_complex_to_magphase_0, '1', blocks_sub_xx_0, '0']
- [blocks_complex_to_magphase_0, '1', blocks_sub_xx_0_0, '0']
- [blocks_complex_to_magphase_0_0, '0', blocks_vector_sink_x_0, '0']
- [blocks_complex_to_magphase_0_0, '1', blocks_sub_xx_0, '1']
- [blocks_magphase_to_complex_0, '0', pad_sink_0, '0']
- [blocks_sub_xx_0, '0', blocks_sub_xx_0_0, '1']
- [blocks_sub_xx_0_0, '0', blocks_magphase_to_complex_0, '1']
- [pad_source_0, '0', blocks_complex_to_magphase_0, '0']
- [pad_source_0_0, '0', blocks_complex_to_magphase_0_0, '0']

metadata:
  file_format: 1
