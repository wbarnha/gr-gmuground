options:
  parameters:
    author: William Barnhart
    category: gmuground
    generate_options: hb
    id: Maximal_Combining
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: digital_mpsk_snr_est_cc_0
  id: digital_mpsk_snr_est_cc
  parameters:
    alpha: filter_alpha
    tag_nsamples: tag_samps
    type: '3'
  states: {}
- name: digital_mpsk_snr_est_cc_0_0
  id: digital_mpsk_snr_est_cc
  parameters:
    alpha: filter_alpha
    tag_nsamples: tag_samps
    type: '3'
  states: {}
- name: filter_alpha
  id: parameter
  parameters:
    label: SNR Filter Alpha
    type: eng_float
    value: '1e-3'
  states: {}
- name: gmuground_sqrt_0
  id: gmuground_sqrt
  parameters:
    type: complex
    vlen: '1'
  states: {}
- name: gmuground_sqrt_0_0
  id: gmuground_sqrt
  parameters:
    type: complex
    vlen: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math, cmath, numpy
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: horz
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: vert
    type: complex
  states: {}
- name: tag_samps
  id: parameter
  parameters:
    label: Samples between tags
    type: intx
    value: '1000'
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_add_xx_0_0, '0', blocks_divide_xx_0_0, '1']
- [blocks_add_xx_1, '0', pad_sink_0, '0']
- [blocks_divide_xx_0, '0', gmuground_sqrt_0, '0']
- [blocks_divide_xx_0_0, '0', gmuground_sqrt_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_1, '1']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_1, '0']
- [digital_mpsk_snr_est_cc_0, '0', blocks_add_xx_0, '0']
- [digital_mpsk_snr_est_cc_0, '0', blocks_add_xx_0_0, '1']
- [digital_mpsk_snr_est_cc_0, '0', blocks_divide_xx_0, '0']
- [digital_mpsk_snr_est_cc_0_0, '0', blocks_add_xx_0, '1']
- [digital_mpsk_snr_est_cc_0_0, '0', blocks_add_xx_0_0, '0']
- [digital_mpsk_snr_est_cc_0_0, '0', blocks_divide_xx_0_0, '0']
- [gmuground_sqrt_0, '0', blocks_multiply_xx_0_0, '1']
- [gmuground_sqrt_0_0, '0', blocks_multiply_xx_0, '1']
- [pad_source_0, '0', blocks_multiply_xx_0_0, '0']
- [pad_source_0, '0', digital_mpsk_snr_est_cc_0, '0']
- [pad_source_1, '0', blocks_multiply_xx_0, '0']
- [pad_source_1, '0', digital_mpsk_snr_est_cc_0_0, '0']

metadata:
  file_format: 1
