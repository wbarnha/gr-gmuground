options:
  parameters:
    author: William Barnhart
    category: gmuground
    description: Demo Decoder
    generate_options: hb_qt_gui
    id: Decode_Demo
    output_language: python
    title: Demo Decoder
  states: {}

blocks:
- name: blocks_selector_3
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: int(sat==4 or sat==5 or sat == 6)
    type: float
  states: {}
- name: blocks_selector_3_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '3'
    output_index: int(sat==0 or sat==4 or sat == 5)
    type: float
  states: {}
- name: floripasat_1_0
  id: floripasat_1
  parameters:
    invert: '1'
  states: {}
- name: funcube_0
  id: funcube
  parameters:
    bfo: '1500'
  states: {}
- name: generic_1k2_afsk_ax25_0
  id: generic_1k2_afsk_ax25
  parameters: {}
  states: {}
- name: inv
  id: parameter
  parameters:
    label: Invert Waveform (Floripa, -1 to invert)
    type: intx
    value: '1'
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    note: 3CAT-2 is non-operational
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: sat
  id: parameter
  parameters:
    label: Satellite
    type: intx
    value: '0'
  states: {}
- name: sat_3cat_2_0
  id: sat_3cat_2
  parameters:
    bfo: '12000'
  states: {}
- name: satellites_ao40_fec_decoder_soft_0
  id: satellites_ao40_fec_decoder_soft
  parameters: {}
  states: {}
- name: satellites_check_address_0
  id: satellites_check_address
  parameters:
    address: 3CAT2
    direction: '"from"'
  states: {}
- name: satellites_floripasat_telemetry_parser_0
  id: satellites_floripasat_telemetry_parser
  parameters: {}
  states: {}
- name: satellites_funcube_telemetry_parser_0
  id: satellites_funcube_telemetry_parser
  parameters: {}
  states: {}
- name: satellites_hdlc_deframer_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'False'
    max_length: '10000'
  states: {}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {}
- name: satellites_sat3cat2_telemetry_parser_0
  id: satellites_sat3cat2_telemetry_parser
  parameters: {}
  states: {}
- name: show_text_0
  id: show_text
  parameters: {}
  states: {}

connections:
- [blocks_selector_3, '0', blocks_selector_3_0, '0']
- [blocks_selector_3, '1', funcube_0, '0']
- [blocks_selector_3_0, '0', generic_1k2_afsk_ax25_0, '0']
- [blocks_selector_3_0, '1', sat_3cat_2_0, '0']
- [blocks_selector_3_0, '2', floripasat_1_0, '0']
- [floripasat_1_0, out, satellites_floripasat_telemetry_parser_0, in]
- [floripasat_1_0, out, show_text_0, disp_pdu]
- [funcube_0, '0', satellites_ao40_fec_decoder_soft_0, '0']
- [generic_1k2_afsk_ax25_0, out, show_text_0, disp_pdu]
- [pad_source_0, '0', blocks_selector_3, '0']
- [sat_3cat_2_0, '0', satellites_hdlc_deframer_0, '0']
- [satellites_ao40_fec_decoder_soft_0, out, satellites_print_timestamp_0, in]
- [satellites_ao40_fec_decoder_soft_0, out, show_text_0, disp_pdu]
- [satellites_check_address_0, ok, satellites_sat3cat2_telemetry_parser_0, in]
- [satellites_check_address_0, ok, show_text_0, disp_pdu]
- [satellites_hdlc_deframer_0, out, satellites_check_address_0, in]
- [satellites_print_timestamp_0, out, satellites_funcube_telemetry_parser_0, in]

metadata:
  file_format: 1
