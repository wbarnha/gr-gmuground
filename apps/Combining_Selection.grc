options:
  parameters:
    author: William Barnhart
    category: gmuground
    description: Combination Selection
    generate_options: hb_qt_gui
    id: Combine_select
    output_language: python
    title: Combination Selection
  states: {}

blocks:
- name: com
  id: variable_qtgui_chooser
  parameters:
    label: Combining Technique
    label0: Selective
    label1: Selective (BPSK Only)
    label2: Equal
    label3: Maximal
    num_opts: '4'
    option1: '1'
    option2: '2'
    option3: '3'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_2
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_imag_0_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: com
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: digital_mpsk_snr_est_cc_0
  id: digital_mpsk_snr_est_cc
  parameters:
    alpha: filter_alpha
    tag_nsamples: tag_samps
    type: '0'
  states: {}
- name: digital_mpsk_snr_est_cc_0_0
  id: digital_mpsk_snr_est_cc
  parameters:
    alpha: filter_alpha
    tag_nsamples: tag_samps
    type: '0'
  states: {}
- name: digital_mpsk_snr_est_cc_0_0_0
  id: digital_mpsk_snr_est_cc
  parameters:
    alpha: filter_alpha
    tag_nsamples: tag_samps
    type: '3'
  states: {}
- name: digital_mpsk_snr_est_cc_0_0_1
  id: digital_mpsk_snr_est_cc
  parameters:
    alpha: filter_alpha
    tag_nsamples: tag_samps
    type: '3'
  states: {}
- name: digital_mpsk_snr_est_cc_0_0_1_0
  id: digital_mpsk_snr_est_cc
  parameters:
    alpha: filter_alpha
    tag_nsamples: tag_samps
    type: '3'
  states: {}
- name: digital_mpsk_snr_est_cc_0_1
  id: digital_mpsk_snr_est_cc
  parameters:
    alpha: filter_alpha
    tag_nsamples: tag_samps
    type: '3'
  states: {}
- name: filter_alpha
  id: parameter
  parameters:
    label: SNR Filter Alpha
    type: eng_float
    value: '1e-3'
  states: {}
- name: gmuground_snr_selector_0
  id: gmuground_snr_selector
  parameters:
    type1: float
    type2: complex
    vlen: '1'
  states: {}
- name: gmuground_snr_selector_0_0
  id: gmuground_snr_selector
  parameters:
    type1: float
    type2: complex
    vlen: '1'
  states: {}
- name: gmuground_sqrt_0
  id: gmuground_sqrt
  parameters:
    type: complex
    vlen: '1'
  states: {}
- name: gmuground_sqrt_0_0
  id: gmuground_sqrt
  parameters:
    type: complex
    vlen: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math, cmath, numpy
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: Combined
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: Ch1
    type: complex
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: Ch2
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    value: 600e3
  states: {}
- name: tag_samps
  id: parameter
  parameters:
    label: Samples between tags
    type: intx
    value: '1000'
  states: {}

connections:
- [blocks_abs_xx_0, '0', gmuground_snr_selector_0_0, '0']
- [blocks_abs_xx_0_0, '0', gmuground_snr_selector_0_0, '1']
- [blocks_add_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_add_xx_0_0, '0', blocks_divide_xx_0_0, '1']
- [blocks_add_xx_1, '0', blocks_selector_0, '3']
- [blocks_add_xx_2, '0', blocks_selector_0, '2']
- [blocks_complex_to_imag_0, '0', blocks_abs_xx_0, '0']
- [blocks_complex_to_imag_0_0, '0', blocks_abs_xx_0_0, '0']
- [blocks_complex_to_mag_0, '0', gmuground_snr_selector_0, '0']
- [blocks_complex_to_mag_0_0, '0', gmuground_snr_selector_0, '1']
- [blocks_divide_xx_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_divide_xx_0_0, '0', gmuground_sqrt_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', digital_mpsk_snr_est_cc_0_1, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', digital_mpsk_snr_est_cc_0_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_1, '1']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_1, '0']
- [blocks_selector_0, '0', pad_sink_0_0, '0']
- [digital_mpsk_snr_est_cc_0, '0', blocks_add_xx_0, '0']
- [digital_mpsk_snr_est_cc_0, '0', blocks_add_xx_0_0, '1']
- [digital_mpsk_snr_est_cc_0, '0', blocks_divide_xx_0, '0']
- [digital_mpsk_snr_est_cc_0_0, '0', blocks_add_xx_0, '1']
- [digital_mpsk_snr_est_cc_0_0, '0', blocks_add_xx_0_0, '0']
- [digital_mpsk_snr_est_cc_0_0, '0', blocks_divide_xx_0_0, '0']
- [digital_mpsk_snr_est_cc_0_0_0, '0', blocks_complex_to_mag_0_0, '0']
- [digital_mpsk_snr_est_cc_0_0_1, '0', blocks_complex_to_imag_0, '0']
- [digital_mpsk_snr_est_cc_0_0_1_0, '0', blocks_complex_to_imag_0_0, '0']
- [digital_mpsk_snr_est_cc_0_1, '0', blocks_complex_to_mag_0, '0']
- [gmuground_snr_selector_0, '0', blocks_selector_0, '0']
- [gmuground_snr_selector_0_0, '0', blocks_selector_0, '1']
- [gmuground_sqrt_0, '0', blocks_multiply_xx_0_0, '1']
- [gmuground_sqrt_0_0, '0', blocks_multiply_xx_0, '1']
- [pad_source_0, '0', blocks_add_xx_2, '0']
- [pad_source_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [pad_source_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [pad_source_0, '0', digital_mpsk_snr_est_cc_0, '0']
- [pad_source_0, '0', digital_mpsk_snr_est_cc_0_0_1_0, '0']
- [pad_source_0, '0', gmuground_snr_selector_0, '2']
- [pad_source_0, '0', gmuground_snr_selector_0_0, '2']
- [pad_source_0, '0', gmuground_sqrt_0, '0']
- [pad_source_0_0, '0', blocks_add_xx_2, '1']
- [pad_source_0_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [pad_source_0_0, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [pad_source_0_0, '0', blocks_multiply_xx_0, '0']
- [pad_source_0_0, '0', digital_mpsk_snr_est_cc_0_0, '0']
- [pad_source_0_0, '0', digital_mpsk_snr_est_cc_0_0_1, '0']
- [pad_source_0_0, '0', gmuground_snr_selector_0, '3']
- [pad_source_0_0, '0', gmuground_snr_selector_0_0, '3']

metadata:
  file_format: 1
