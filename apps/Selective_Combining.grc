options:
  parameters:
    author: William Barnhart
    category: gmuground
    description: Uses two receiving channels for opposite polarizations to produce a signal with greater SNR.
    generate_options: hb
    id: Selective_Combining
    output_language: python
    title: Selective Signal Combining
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_imag_0_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_imag_0_0_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: digital_mpsk_snr_est_cc_0
  id: digital_mpsk_snr_est_cc
  parameters:
    alpha: '0.001'
    tag_nsamples: '10000'
    type: '0'
  states: {}
- name: digital_mpsk_snr_est_cc_0_0
  id: digital_mpsk_snr_est_cc
  parameters:
    alpha: '0.001'
    tag_nsamples: '10000'
    type: '0'
  states: {}
- name: gmuground_snr_selector_0
  id: gmuground_snr_selector
  parameters:
    type1: float
    type2: complex
    vlen: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: horz
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: vert
    type: complex
  states: {}

connections:
- [blocks_abs_xx_0, '0', gmuground_snr_selector_0, '0']
- [blocks_abs_xx_0_0, '0', gmuground_snr_selector_0, '1']
- [blocks_complex_to_imag_0_0, '0', blocks_abs_xx_0, '0']
- [blocks_complex_to_imag_0_0_0, '0', blocks_abs_xx_0_0, '0']
- [digital_mpsk_snr_est_cc_0, '0', blocks_complex_to_imag_0_0, '0']
- [digital_mpsk_snr_est_cc_0_0, '0', blocks_complex_to_imag_0_0_0, '0']
- [gmuground_snr_selector_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', digital_mpsk_snr_est_cc_0, '0']
- [pad_source_0, '0', gmuground_snr_selector_0, '2']
- [pad_source_1, '0', digital_mpsk_snr_est_cc_0_0, '0']
- [pad_source_1, '0', gmuground_snr_selector_0, '3']

metadata:
  file_format: 1
