options:
  parameters:
    author: William Barnhart
    category: gmuground
    description: Uses two receiving channels for opposite polarizations to produce a signal with greater SNR.
    generate_options: hb
    id: Selective_Combining
    output_language: python
    title: Selective Signal Combining
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: digital_mpsk_snr_est_cc_0
  id: digital_mpsk_snr_est_cc
  parameters:
    alpha: filter_alpha
    tag_nsamples: tag_samps
    type: '3'
  states: {}
- name: digital_mpsk_snr_est_cc_0_0
  id: digital_mpsk_snr_est_cc
  parameters:
    alpha: filter_alpha
    tag_nsamples: tag_samps
    type: '3'
  states: {}
- name: filter_alpha
  id: parameter
  parameters:
    label: SNR Filter Alpha
    type: eng_float
    value: '1e-3'
  states: {}
- name: gmuground_snr_selector_0
  id: gmuground_snr_selector
  parameters:
    type1: float
    type2: complex
    vlen: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: horz
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: vert
    type: complex
  states: {}
- name: tag_samps
  id: parameter
  parameters:
    label: Samples between tags
    type: intx
    value: '1000'
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', gmuground_snr_selector_0, '1']
- [blocks_complex_to_mag_0_0, '0', gmuground_snr_selector_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', digital_mpsk_snr_est_cc_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', digital_mpsk_snr_est_cc_0_0, '0']
- [digital_mpsk_snr_est_cc_0, '0', blocks_complex_to_mag_0, '0']
- [digital_mpsk_snr_est_cc_0_0, '0', blocks_complex_to_mag_0_0, '0']
- [gmuground_snr_selector_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [pad_source_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [pad_source_0, '0', gmuground_snr_selector_0, '2']
- [pad_source_1, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [pad_source_1, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [pad_source_1, '0', gmuground_snr_selector_0, '3']

metadata:
  file_format: 1
