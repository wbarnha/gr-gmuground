options:
  parameters:
    author: William Barnhart
    generate_options: qt_gui
    id: sdrangel_sink
    output_language: python
    title: SDRAngel Sink
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: sat
  id: variable_qtgui_chooser
  parameters:
    label: Demo Satellite
    labels: '["3CAT-2","AO-73","FloripaSat 1","ITASAT 1","JY1SAT (JO-97)","NAYIF-1 (EO-88)","UKUBE-1"]'
    num_opts: '0'
    options: '[0,1,2,3,4,5,6]'
    type: int
    value: '0'
  states: {}
- name: sat_type
  id: variable
  parameters:
    value: '{0:''3CAT-2'',1:''AO-73'',2:''FloripaSat 1'',3:''ITASAT 1'',4:''JY1-Sat'',5:''Nayif-1'',6:''UKube-1''}'
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    comment: From SDRAngel
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '7356'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: satellites_satellite_decoder_0
  id: satellites_satellite_decoder
  parameters:
    definition: name
    file: /usr/local/lib/python3/dist-packages/satellites/satyaml/1KUNS-PF.yml
    name: sat_type[sat]
    norad: '99999'
    samp_rate: samp_rate
  states: {}

connections:
- [blocks_complex_to_real_0_0, '0', satellites_satellite_decoder_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_udp_source_0, '0', blocks_throttle_0, '0']
- [satellites_satellite_decoder_0, out, blocks_message_debug_1, print]

metadata:
  file_format: 1
